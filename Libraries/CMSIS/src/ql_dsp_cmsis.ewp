# IAR project ql_dsp_cmsis.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; __FPU_PRESENT; ENABLE_FFT_64_ONLY; ARM_TABLE_TWIDDLECOEF_F32_64; ARM_TABLE_BITREVIDX_FLT_64; ARM_TABLE_TWIDDLECOEF_RFFT_F32_128
  ICCARM.CCIncludePath2: ..\Inc; ..\Core\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group cmsis
    ./: arm_bitreversal2.S arm_cfft_f32.c arm_cfft_radix8_f32.c arm_common_tables.c arm_dot_prod_f32.c arm_q15_to_float.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c
  group cmsis/inc
    ../Inc/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
