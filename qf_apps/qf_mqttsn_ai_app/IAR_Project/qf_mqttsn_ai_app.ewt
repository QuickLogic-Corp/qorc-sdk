<?xml version="1.0" encoding="UTF-8"?>
<project>
    <fileVersion>3</fileVersion>
    <configuration>
        <name>Debug</name>
        <toolchain>
            <name>ARM</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-STAT</name>
            <archiveVersion>261</archiveVersion>
            <data>
                <version>261</version>
                <cstatargs>
                    <useExtraArgs>0</useExtraArgs>
                    <extraArgs></extraArgs>
                    <analyzeTimeoutEnabled>1</analyzeTimeoutEnabled>
                    <analyzeTimeout>600</analyzeTimeout>
                    <enableParallel>1</enableParallel>
                    <parallelThreads>6</parallelThreads>
                    <enableFalsePositives>0</enableFalsePositives>
                    <messagesLimitEnabled>1</messagesLimitEnabled>
                    <messagesLimit>100</messagesLimit>
                </cstatargs>
                <cstat_settings>
                    <cstat_version>1.5.4</cstat_version>
                    <checks_tree>
                        <package name="STDCHECKS" enabled="true">
                            <group enabled="true" name="ARR">
                                <check name="ARR-inv-index-pos" enabled="true" />
                                <check name="ARR-inv-index-ptr-pos" enabled="true" />
                                <check name="ARR-inv-index-ptr" enabled="true" />
                                <check name="ARR-inv-index" enabled="true" />
                                <check name="ARR-neg-index" enabled="true" />
                                <check name="ARR-uninit-index" enabled="true" />
                            </group>
                            <group enabled="true" name="ATH">
                                <check name="ATH-cmp-float" enabled="true" />
                                <check name="ATH-cmp-unsign-neg" enabled="true" />
                                <check name="ATH-cmp-unsign-pos" enabled="true" />
                                <check name="ATH-div-0-assign" enabled="true" />
                                <check name="ATH-div-0-cmp-aft" enabled="false" />
                                <check name="ATH-div-0-cmp-bef" enabled="true" />
                                <check name="ATH-div-0-interval" enabled="true" />
                                <check name="ATH-div-0-pos" enabled="true" />
                                <check name="ATH-div-0-unchk-global" enabled="true" />
                                <check name="ATH-div-0-unchk-local" enabled="true" />
                                <check name="ATH-div-0-unchk-param" enabled="true" />
                                <check name="ATH-div-0" enabled="true" />
                                <check name="ATH-inc-bool" enabled="true" />
                                <check name="ATH-malloc-overrun" enabled="true" />
                                <check name="ATH-neg-check-nonneg" enabled="true" />
                                <check name="ATH-neg-check-pos" enabled="true" />
                                <check name="ATH-new-overrun" enabled="true" />
                                <check name="ATH-overflow-cast" enabled="false" />
                                <check name="ATH-overflow" enabled="true" />
                                <check name="ATH-shift-bounds" enabled="true" />
                                <check name="ATH-shift-neg" enabled="true" />
                                <check name="ATH-sizeof-by-sizeof" enabled="true" />
                            </group>
                            <group enabled="true" name="CAST">
                                <check name="CAST-old-style" enabled="false" />
                            </group>
                            <group enabled="true" name="CATCH">
                                <check name="CATCH-object-slicing" enabled="true" />
                                <check name="CATCH-xtor-bad-member" enabled="false" />
                            </group>
                            <group enabled="true" name="COMMA">
                                <check name="COMMA-overload" enabled="false" />
                            </group>
                            <group enabled="true" name="COMMENT">
                                <check name="COMMENT-nested" enabled="true" />
                            </group>
                            <group enabled="true" name="CONST">
                                <check name="CONST-member-ret" enabled="true" />
                            </group>
                            <group enabled="true" name="COP">
                                <check name="COP-alloc-ctor" enabled="false" />
                                <check name="COP-assign-op-ret" enabled="true" />
                                <check name="COP-assign-op-self" enabled="true" />
                                <check name="COP-assign-op" enabled="true" />
                                <check name="COP-copy-ctor" enabled="true" />
                                <check name="COP-dealloc-dtor" enabled="false" />
                                <check name="COP-dtor-throw" enabled="true" />
                                <check name="COP-dtor" enabled="true" />
                                <check name="COP-init-order" enabled="true" />
                                <check name="COP-init-uninit" enabled="true" />
                                <check name="COP-member-uninit" enabled="true" />
                            </group>
                            <group enabled="true" name="CPU">
                                <check name="CPU-ctor-call-virt" enabled="true" />
                                <check name="CPU-ctor-implicit" enabled="false" />
                                <check name="CPU-delete-throw" enabled="true" />
                                <check name="CPU-delete-void" enabled="true" />
                                <check name="CPU-dtor-call-virt" enabled="true" />
                                <check name="CPU-malloc-class" enabled="true" />
                                <check name="CPU-nonvirt-dtor" enabled="true" />
                                <check name="CPU-return-ref-to-class-data" enabled="true" />
                            </group>
                            <group enabled="true" name="DECL">
                                <check name="DECL-implicit-int" enabled="false" />
                            </group>
                            <group enabled="true" name="DEFINE">
                                <check name="DEFINE-hash-multiple" enabled="true" />
                            </group>
                            <group enabled="true" name="ENUM">
                                <check name="ENUM-bounds" enabled="false" />
                            </group>
                            <group enabled="true" name="EXP">
                                <check name="EXP-cond-assign" enabled="true" />
                                <check name="EXP-dangling-else" enabled="true" />
                                <check name="EXP-loop-exit" enabled="true" />
                                <check name="EXP-main-ret-int" enabled="false" />
                                <check name="EXP-null-stmt" enabled="false" />
                                <check name="EXP-stray-semicolon" enabled="false" />
                            </group>
                            <group enabled="true" name="EXPR">
                                <check name="EXPR-const-overflow" enabled="true" />
                            </group>
                            <group enabled="true" name="FPT">
                                <check name="FPT-cmp-null" enabled="true" />
                                <check name="FPT-literal" enabled="false" />
                                <check name="FPT-misuse" enabled="true" />
                            </group>
                            <group enabled="true" name="FUNC">
                                <check name="FUNC-implicit-decl" enabled="false" />
                                <check name="FUNC-unprototyped-all" enabled="false" />
                                <check name="FUNC-unprototyped-used" enabled="true" />
                            </group>
                            <group enabled="true" name="INCLUDE">
                                <check name="INCLUDE-c-file" enabled="false" />
                            </group>
                            <group enabled="true" name="INT">
                                <check name="INT-use-signed-as-unsigned-pos" enabled="false" />
                                <check name="INT-use-signed-as-unsigned" enabled="true" />
                            </group>
                            <group enabled="true" name="ITR">
                                <check name="ITR-end-cmp-aft" enabled="true" />
                                <check name="ITR-end-cmp-bef" enabled="true" />
                                <check name="ITR-invalidated" enabled="true" />
                                <check name="ITR-mismatch-alg" enabled="false" />
                                <check name="ITR-store" enabled="false" />
                                <check name="ITR-uninit" enabled="true" />
                            </group>
                            <group enabled="true" name="LIB">
                                <check name="LIB-bsearch-overrun-pos" enabled="false" />
                                <check name="LIB-bsearch-overrun" enabled="false" />
                                <check name="LIB-fn-unsafe" enabled="false" />
                                <check name="LIB-fread-overrun-pos" enabled="false" />
                                <check name="LIB-fread-overrun" enabled="true" />
                                <check name="LIB-memchr-overrun-pos" enabled="false" />
                                <check name="LIB-memchr-overrun" enabled="true" />
                                <check name="LIB-memcpy-overrun-pos" enabled="false" />
                                <check name="LIB-memcpy-overrun" enabled="true" />
                                <check name="LIB-memset-overrun-pos" enabled="false" />
                                <check name="LIB-memset-overrun" enabled="true" />
                                <check name="LIB-putenv" enabled="false" />
                                <check name="LIB-qsort-overrun-pos" enabled="false" />
                                <check name="LIB-qsort-overrun" enabled="false" />
                                <check name="LIB-return-const" enabled="true" />
                                <check name="LIB-return-error" enabled="true" />
                                <check name="LIB-return-leak" enabled="true" />
                                <check name="LIB-return-neg" enabled="true" />
                                <check name="LIB-return-null" enabled="true" />
                                <check name="LIB-sprintf-overrun" enabled="false" />
                                <check name="LIB-std-sort-overrun-pos" enabled="false" />
                                <check name="LIB-std-sort-overrun" enabled="true" />
                                <check name="LIB-strcat-overrun-pos" enabled="false" />
                                <check name="LIB-strcat-overrun" enabled="true" />
                                <check name="LIB-strcpy-overrun-pos" enabled="false" />
                                <check name="LIB-strcpy-overrun" enabled="true" />
                                <check name="LIB-strncat-overrun-pos" enabled="false" />
                                <check name="LIB-strncat-overrun" enabled="true" />
                                <check name="LIB-strncmp-overrun-pos" enabled="false" />
                                <check name="LIB-strncmp-overrun" enabled="true" />
                                <check name="LIB-strncpy-overrun-pos" enabled="false" />
                                <check name="LIB-strncpy-overrun" enabled="true" />
                            </group>
                            <group enabled="true" name="LOGIC">
                                <check name="LOGIC-overload" enabled="false" />
                            </group>
                            <group enabled="true" name="MEM">
                                <check name="MEM-delete-array-op" enabled="true" />
                                <check name="MEM-delete-op" enabled="true" />
                                <check name="MEM-double-free-alias" enabled="true" />
                                <check name="MEM-double-free-some" enabled="true" />
                                <check name="MEM-double-free" enabled="true" />
                                <check name="MEM-free-field" enabled="true" />
                                <check name="MEM-free-fptr" enabled="true" />
                                <check name="MEM-free-no-alloc-struct" enabled="false" />
                                <check name="MEM-free-no-alloc" enabled="false" />
                                <check name="MEM-free-no-use" enabled="true" />
                                <check name="MEM-free-op" enabled="true" />
                                <check name="MEM-free-struct-field" enabled="true" />
                                <check name="MEM-free-variable-alias" enabled="true" />
                                <check name="MEM-free-variable" enabled="true" />
                                <check name="MEM-leak-alias" enabled="true" />
                                <check name="MEM-leak" enabled="false" />
                                <check name="MEM-malloc-arith" enabled="false" />
                                <check name="MEM-malloc-diff-type" enabled="true" />
                                <check name="MEM-malloc-sizeof-ptr" enabled="true" />
                                <check name="MEM-malloc-sizeof" enabled="true" />
                                <check name="MEM-malloc-strlen" enabled="false" />
                                <check name="MEM-realloc-diff-type" enabled="true" />
                                <check name="MEM-return-free" enabled="true" />
                                <check name="MEM-return-no-assign" enabled="true" />
                                <check name="MEM-stack-global-field" enabled="true" />
                                <check name="MEM-stack-global" enabled="true" />
                                <check name="MEM-stack-param-ref" enabled="true" />
                                <check name="MEM-stack-param" enabled="true" />
                                <check name="MEM-stack-pos" enabled="true" />
                                <check name="MEM-stack-ref" enabled="true" />
                                <check name="MEM-stack" enabled="true" />
                                <check name="MEM-use-free-all" enabled="true" />
                                <check name="MEM-use-free-some" enabled="true" />
                            </group>
                            <group enabled="true" name="PTR">
                                <check name="PTR-arith-field" enabled="true" />
                                <check name="PTR-arith-stack" enabled="true" />
                                <check name="PTR-arith-var" enabled="true" />
                                <check name="PTR-cmp-str-lit" enabled="true" />
                                <check name="PTR-null-assign-fun-pos" enabled="false" />
                                <check name="PTR-null-assign-pos" enabled="false" />
                                <check name="PTR-null-assign" enabled="true" />
                                <check name="PTR-null-cmp-aft" enabled="true" />
                                <check name="PTR-null-cmp-bef-fun" enabled="true" />
                                <check name="PTR-null-cmp-bef" enabled="true" />
                                <check name="PTR-null-fun-pos" enabled="true" />
                                <check name="PTR-null-literal-pos" enabled="false" />
                                <check name="PTR-overload" enabled="false" />
                                <check name="PTR-singleton-arith-pos" enabled="false" />
                                <check name="PTR-singleton-arith" enabled="true" />
                                <check name="PTR-unchk-param-some" enabled="true" />
                                <check name="PTR-unchk-param" enabled="false" />
                                <check name="PTR-uninit-pos" enabled="false" />
                                <check name="PTR-uninit" enabled="true" />
                            </group>
                            <group enabled="true" name="RED">
                                <check name="RED-alloc-zero-bytes" enabled="false" />
                                <check name="RED-case-reach" enabled="false" />
                                <check name="RED-cmp-always" enabled="false" />
                                <check name="RED-cmp-never" enabled="false" />
                                <check name="RED-cond-always" enabled="false" />
                                <check name="RED-cond-const-assign" enabled="true" />
                                <check name="RED-cond-const-expr" enabled="false" />
                                <check name="RED-cond-const" enabled="false" />
                                <check name="RED-cond-never" enabled="false" />
                                <check name="RED-dead" enabled="true" />
                                <check name="RED-expr" enabled="false" />
                                <check name="RED-func-no-effect" enabled="false" />
                                <check name="RED-local-hides-global" enabled="true" />
                                <check name="RED-local-hides-local" enabled="false" />
                                <check name="RED-local-hides-member" enabled="false" />
                                <check name="RED-local-hides-param" enabled="true" />
                                <check name="RED-no-effect" enabled="false" />
                                <check name="RED-self-assign" enabled="true" />
                                <check name="RED-unused-assign" enabled="true" />
                                <check name="RED-unused-param" enabled="false" />
                                <check name="RED-unused-return-val" enabled="false" />
                                <check name="RED-unused-val" enabled="false" />
                                <check name="RED-unused-var-all" enabled="true" />
                            </group>
                            <group enabled="true" name="RESOURCE">
                                <check name="RESOURCE-deref-file" enabled="false" />
                                <check name="RESOURCE-double-close" enabled="true" />
                                <check name="RESOURCE-file-no-close-all" enabled="true" />
                                <check name="RESOURCE-file-pos-neg" enabled="false" />
                                <check name="RESOURCE-file-use-after-close" enabled="true" />
                                <check name="RESOURCE-implicit-deref-file" enabled="false" />
                                <check name="RESOURCE-write-ronly-file" enabled="true" />
                            </group>
                            <group enabled="true" name="SIZEOF">
                                <check name="SIZEOF-side-effect" enabled="true" />
                            </group>
                            <group enabled="true" name="SPC">
                                <check name="SPC-order" enabled="true" />
                                <check name="SPC-uninit-arr-all" enabled="false" />
                                <check name="SPC-uninit-struct-field-heap" enabled="true" />
                                <check name="SPC-uninit-struct-field" enabled="false" />
                                <check name="SPC-uninit-struct" enabled="true" />
                                <check name="SPC-uninit-var-all" enabled="true" />
                                <check name="SPC-uninit-var-some" enabled="true" />
                                <check name="SPC-volatile-reads" enabled="false" />
                                <check name="SPC-volatile-writes" enabled="false" />
                            </group>
                            <group enabled="true" name="STRUCT">
                                <check name="STRUCT-signed-bit" enabled="false" />
                            </group>
                            <group enabled="true" name="SWITCH">
                                <check name="SWITCH-fall-through" enabled="true" />
                            </group>
                            <group enabled="true" name="THROW">
                                <check name="THROW-empty" enabled="false" />
                                <check name="THROW-main" enabled="false" />
                                <check name="THROW-null" enabled="true" />
                                <check name="THROW-ptr" enabled="true" />
                                <check name="THROW-static" enabled="true" />
                                <check name="THROW-unhandled" enabled="true" />
                            </group>
                            <group enabled="true" name="UNION">
                                <check name="UNION-overlap-assign" enabled="true" />
                                <check name="UNION-type-punning" enabled="true" />
                            </group>
                        </package>
                        <package name="CERT" enabled="false">
                            <group enabled="true" name="CERT-EXP">
                                <check name="CERT-EXP19-C" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-FIO">
                                <check name="CERT-FIO37-C" enabled="true" />
                                <check name="CERT-FIO38-C" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-SIG">
                                <check name="CERT-SIG31-C" enabled="true" />
                            </group>
                        </package>
                        <package name="SECURITY" enabled="false">
                            <group enabled="true" name="SEC-BUFFER">
                                <check name="SEC-BUFFER-memory-leak-alias" enabled="true" />
                                <check name="SEC-BUFFER-memory-leak" enabled="false" />
                                <check name="SEC-BUFFER-memset-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-memset-overrun" enabled="true" />
                                <check name="SEC-BUFFER-qsort-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-qsort-overrun" enabled="true" />
                                <check name="SEC-BUFFER-sprintf-overrun" enabled="true" />
                                <check name="SEC-BUFFER-std-sort-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-std-sort-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strcat-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strcat-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strcpy-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strcpy-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strncat-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strncat-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strncmp-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strncmp-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strncpy-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strncpy-overrun" enabled="true" />
                                <check name="SEC-BUFFER-tainted-alloc-size" enabled="true" />
                                <check name="SEC-BUFFER-tainted-copy-length" enabled="true" />
                                <check name="SEC-BUFFER-tainted-copy" enabled="true" />
                                <check name="SEC-BUFFER-tainted-index" enabled="true" />
                                <check name="SEC-BUFFER-tainted-offset" enabled="true" />
                                <check name="SEC-BUFFER-use-after-free-all" enabled="true" />
                                <check name="SEC-BUFFER-use-after-free-some" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-DIV-0">
                                <check name="SEC-DIV-0-compare-after" enabled="true" />
                                <check name="SEC-DIV-0-compare-before" enabled="true" />
                                <check name="SEC-DIV-0-tainted" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-FILEOP">
                                <check name="SEC-FILEOP-open-no-close" enabled="true" />
                                <check name="SEC-FILEOP-path-traversal" enabled="false" />
                                <check name="SEC-FILEOP-use-after-close" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-INJECTION">
                                <check name="SEC-INJECTION-sql" enabled="false" />
                                <check name="SEC-INJECTION-xpath" enabled="false" />
                            </group>
                            <group enabled="true" name="SEC-LOOP">
                                <check name="SEC-LOOP-tainted-bound" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-NULL">
                                <check name="SEC-NULL-assignment-fun-pos" enabled="false" />
                                <check name="SEC-NULL-assignment" enabled="true" />
                                <check name="SEC-NULL-cmp-aft" enabled="true" />
                                <check name="SEC-NULL-cmp-bef-fun" enabled="true" />
                                <check name="SEC-NULL-cmp-bef" enabled="true" />
                                <check name="SEC-NULL-literal-pos" enabled="false" />
                            </group>
                            <group enabled="true" name="SEC-STRING">
                                <check name="SEC-STRING-format-string" enabled="true" />
                                <check name="SEC-STRING-hard-coded-credentials" enabled="false" />
                            </group>
                        </package>
                        <package name="MISRAC2004" enabled="false">
                            <group enabled="true" name="MISRAC2004-1">
                                <check name="MISRAC2004-1.1" enabled="true" />
                                <check name="MISRAC2004-1.2_a" enabled="true" />
                                <check name="MISRAC2004-1.2_b" enabled="true" />
                                <check name="MISRAC2004-1.2_c" enabled="true" />
                                <check name="MISRAC2004-1.2_d" enabled="true" />
                                <check name="MISRAC2004-1.2_e" enabled="true" />
                                <check name="MISRAC2004-1.2_f" enabled="true" />
                                <check name="MISRAC2004-1.2_g" enabled="true" />
                                <check name="MISRAC2004-1.2_h" enabled="true" />
                                <check name="MISRAC2004-1.2_i" enabled="true" />
                                <check name="MISRAC2004-1.2_j" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-2">
                                <check name="MISRAC2004-2.1" enabled="true" />
                                <check name="MISRAC2004-2.2" enabled="true" />
                                <check name="MISRAC2004-2.3" enabled="true" />
                                <check name="MISRAC2004-2.4" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2004-5">
                                <check name="MISRAC2004-5.2" enabled="true" />
                                <check name="MISRAC2004-5.3" enabled="true" />
                                <check name="MISRAC2004-5.4" enabled="true" />
                                <check name="MISRAC2004-5.5" enabled="false" />
                                <check name="MISRAC2004-5.6" enabled="false" />
                                <check name="MISRAC2004-5.7" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2004-6">
                                <check name="MISRAC2004-6.1" enabled="true" />
                                <check name="MISRAC2004-6.2" enabled="true" />
                                <check name="MISRAC2004-6.3" enabled="false" />
                                <check name="MISRAC2004-6.4" enabled="true" />
                                <check name="MISRAC2004-6.5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-7">
                                <check name="MISRAC2004-7.1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-8">
                                <check name="MISRAC2004-8.1" enabled="true" />
                                <check name="MISRAC2004-8.2" enabled="true" />
                                <check name="MISRAC2004-8.3" enabled="true" />
                                <check name="MISRAC2004-8.5_a" enabled="true" />
                                <check name="MISRAC2004-8.5_b" enabled="true" />
                                <check name="MISRAC2004-8.6" enabled="true" />
                                <check name="MISRAC2004-8.7" enabled="true" />
                                <check name="MISRAC2004-8.8_a" enabled="true" />
                                <check name="MISRAC2004-8.8_b" enabled="true" />
                                <check name="MISRAC2004-8.12" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-8 10">
                                <check name="MISRAC2004-8.10" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-9">
                                <check name="MISRAC2004-9.1_a" enabled="true" />
                                <check name="MISRAC2004-9.1_b" enabled="true" />
                                <check name="MISRAC2004-9.1_c" enabled="true" />
                                <check name="MISRAC2004-9.2" enabled="true" />
                                <check name="MISRAC2004-9.3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-10">
                                <check name="MISRAC2004-10.1_a" enabled="true" />
                                <check name="MISRAC2004-10.1_b" enabled="true" />
                                <check name="MISRAC2004-10.1_c" enabled="true" />
                                <check name="MISRAC2004-10.1_d" enabled="true" />
                                <check name="MISRAC2004-10.2_a" enabled="true" />
                                <check name="MISRAC2004-10.2_b" enabled="true" />
                                <check name="MISRAC2004-10.2_c" enabled="true" />
                                <check name="MISRAC2004-10.2_d" enabled="true" />
                                <check name="MISRAC2004-10.3" enabled="true" />
                                <check name="MISRAC2004-10.4" enabled="true" />
                                <check name="MISRAC2004-10.5" enabled="true" />
                                <check name="MISRAC2004-10.6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-11">
                                <check name="MISRAC2004-11.1" enabled="true" />
                                <check name="MISRAC2004-11.3" enabled="false" />
                                <check name="MISRAC2004-11.4" enabled="false" />
                                <check name="MISRAC2004-11.5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-12">
                                <check name="MISRAC2004-12.1" enabled="false" />
                                <check name="MISRAC2004-12.2_a" enabled="true" />
                                <check name="MISRAC2004-12.2_b" enabled="true" />
                                <check name="MISRAC2004-12.2_c" enabled="true" />
                                <check name="MISRAC2004-12.3" enabled="true" />
                                <check name="MISRAC2004-12.4" enabled="true" />
                                <check name="MISRAC2004-12.5" enabled="true" />
                                <check name="MISRAC2004-12.6_a" enabled="false" />
                                <check name="MISRAC2004-12.6_b" enabled="false" />
                                <check name="MISRAC2004-12.7" enabled="true" />
                                <check name="MISRAC2004-12.8" enabled="true" />
                                <check name="MISRAC2004-12.9" enabled="true" />
                                <check name="MISRAC2004-12.10" enabled="true" />
                                <check name="MISRAC2004-12.11" enabled="false" />
                                <check name="MISRAC2004-12.12_a" enabled="true" />
                                <check name="MISRAC2004-12.12_b" enabled="true" />
                                <check name="MISRAC2004-12.13" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2004-13">
                                <check name="MISRAC2004-13.1" enabled="true" />
                                <check name="MISRAC2004-13.2_a" enabled="false" />
                                <check name="MISRAC2004-13.2_b" enabled="false" />
                                <check name="MISRAC2004-13.2_c" enabled="false" />
                                <check name="MISRAC2004-13.2_d" enabled="false" />
                                <check name="MISRAC2004-13.2_e" enabled="false" />
                                <check name="MISRAC2004-13.3" enabled="true" />
                                <check name="MISRAC2004-13.4" enabled="true" />
                                <check name="MISRAC2004-13.5" enabled="true" />
                                <check name="MISRAC2004-13.6" enabled="true" />
                                <check name="MISRAC2004-13.7_a" enabled="true" />
                                <check name="MISRAC2004-13.7_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-14">
                                <check name="MISRAC2004-14.1" enabled="true" />
                                <check name="MISRAC2004-14.2" enabled="true" />
                                <check name="MISRAC2004-14.3" enabled="true" />
                                <check name="MISRAC2004-14.4" enabled="true" />
                                <check name="MISRAC2004-14.5" enabled="true" />
                                <check name="MISRAC2004-14.6" enabled="true" />
                                <check name="MISRAC2004-14.7" enabled="true" />
                                <check name="MISRAC2004-14.8_a" enabled="true" />
                                <check name="MISRAC2004-14.8_b" enabled="true" />
                                <check name="MISRAC2004-14.8_c" enabled="true" />
                                <check name="MISRAC2004-14.8_d" enabled="true" />
                                <check name="MISRAC2004-14.9" enabled="true" />
                                <check name="MISRAC2004-14.10" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-15">
                                <check name="MISRAC2004-15.0" enabled="true" />
                                <check name="MISRAC2004-15.1" enabled="true" />
                                <check name="MISRAC2004-15.2" enabled="true" />
                                <check name="MISRAC2004-15.3" enabled="true" />
                                <check name="MISRAC2004-15.4" enabled="true" />
                                <check name="MISRAC2004-15.5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-16">
                                <check name="MISRAC2004-16.1" enabled="true" />
                                <check name="MISRAC2004-16.2_a" enabled="true" />
                                <check name="MISRAC2004-16.2_b" enabled="true" />
                                <check name="MISRAC2004-16.3" enabled="true" />
                                <check name="MISRAC2004-16.4" enabled="true" />
                                <check name="MISRAC2004-16.5" enabled="true" />
                                <check name="MISRAC2004-16.7" enabled="true" />
                                <check name="MISRAC2004-16.8" enabled="true" />
                                <check name="MISRAC2004-16.9" enabled="true" />
                                <check name="MISRAC2004-16.10" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-17">
                                <check name="MISRAC2004-17.1_a" enabled="true" />
                                <check name="MISRAC2004-17.1_b" enabled="true" />
                                <check name="MISRAC2004-17.1_c" enabled="true" />
                                <check name="MISRAC2004-17.2" enabled="true" />
                                <check name="MISRAC2004-17.3" enabled="true" />
                                <check name="MISRAC2004-17.4_a" enabled="true" />
                                <check name="MISRAC2004-17.4_b" enabled="true" />
                                <check name="MISRAC2004-17.5" enabled="true" />
                                <check name="MISRAC2004-17.6_a" enabled="true" />
                                <check name="MISRAC2004-17.6_b" enabled="true" />
                                <check name="MISRAC2004-17.6_c" enabled="true" />
                                <check name="MISRAC2004-17.6_d" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-18">
                                <check name="MISRAC2004-18.1" enabled="true" />
                                <check name="MISRAC2004-18.2" enabled="true" />
                                <check name="MISRAC2004-18.4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-19">
                                <check name="MISRAC2004-19.1" enabled="false" />
                                <check name="MISRAC2004-19.2" enabled="false" />
                                <check name="MISRAC2004-19.4" enabled="true" />
                                <check name="MISRAC2004-19.5" enabled="true" />
                                <check name="MISRAC2004-19.6" enabled="true" />
                                <check name="MISRAC2004-19.7" enabled="false" />
                                <check name="MISRAC2004-19.10" enabled="true" />
                                <check name="MISRAC2004-19.12" enabled="true" />
                                <check name="MISRAC2004-19.13" enabled="false" />
                                <check name="MISRAC2004-19.15" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-20">
                                <check name="MISRAC2004-20.1" enabled="true" />
                                <check name="MISRAC2004-20.2" enabled="true" />
                                <check name="MISRAC2004-20.3_a" enabled="true" />
                                <check name="MISRAC2004-20.3_b" enabled="true" />
                                <check name="MISRAC2004-20.3_c" enabled="true" />
                                <check name="MISRAC2004-20.3_d" enabled="true" />
                                <check name="MISRAC2004-20.3_e" enabled="true" />
                                <check name="MISRAC2004-20.3_f" enabled="true" />
                                <check name="MISRAC2004-20.3_g" enabled="true" />
                                <check name="MISRAC2004-20.3_h" enabled="true" />
                                <check name="MISRAC2004-20.3_i" enabled="true" />
                                <check name="MISRAC2004-20.4" enabled="true" />
                                <check name="MISRAC2004-20.5" enabled="true" />
                                <check name="MISRAC2004-20.6" enabled="true" />
                                <check name="MISRAC2004-20.7" enabled="true" />
                                <check name="MISRAC2004-20.8" enabled="true" />
                                <check name="MISRAC2004-20.9" enabled="true" />
                                <check name="MISRAC2004-20.10" enabled="true" />
                                <check name="MISRAC2004-20.11" enabled="true" />
                                <check name="MISRAC2004-20.12" enabled="true" />
                            </group>
                        </package>
                        <package name="MISRAC2012" enabled="false">
                            <group enabled="true" name="MISRAC2012-Dir-4">
                                <check name="MISRAC2012-Dir-4.3" enabled="true" />
                                <check name="MISRAC2012-Dir-4.4" enabled="false" />
                                <check name="MISRAC2012-Dir-4.5" enabled="false" />
                                <check name="MISRAC2012-Dir-4.6_a" enabled="false" />
                                <check name="MISRAC2012-Dir-4.6_b" enabled="false" />
                                <check name="MISRAC2012-Dir-4.7_a" enabled="false" />
                                <check name="MISRAC2012-Dir-4.7_b" enabled="false" />
                                <check name="MISRAC2012-Dir-4.7_c" enabled="false" />
                                <check name="MISRAC2012-Dir-4.8" enabled="false" />
                                <check name="MISRAC2012-Dir-4.9" enabled="false" />
                                <check name="MISRAC2012-Dir-4.10" enabled="true" />
                                <check name="MISRAC2012-Dir-4.11_a" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_b" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_c" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_d" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_e" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_f" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_g" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_h" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_i" enabled="false" />
                                <check name="MISRAC2012-Dir-4.12" enabled="false" />
                                <check name="MISRAC2012-Dir-4.13_b" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_c" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_d" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_e" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_f" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_g" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_h" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-1">
                                <check name="MISRAC2012-Rule-1.3_a" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_b" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_c" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_d" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_e" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_f" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_g" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_h" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_i" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_j" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_k" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_m" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_n" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_o" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_p" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_q" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_r" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_s" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_t" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_u" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_v" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_w" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-2">
                                <check name="MISRAC2012-Rule-2.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-2.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-2.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-2.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-2.2_c" enabled="true" />
                                <check name="MISRAC2012-Rule-2.3" enabled="false" />
                                <check name="MISRAC2012-Rule-2.4" enabled="false" />
                                <check name="MISRAC2012-Rule-2.5" enabled="false" />
                                <check name="MISRAC2012-Rule-2.6" enabled="false" />
                                <check name="MISRAC2012-Rule-2.7" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-3">
                                <check name="MISRAC2012-Rule-3.1" enabled="true" />
                                <check name="MISRAC2012-Rule-3.2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-5">
                                <check name="MISRAC2012-Rule-5.1" enabled="true" />
                                <check name="MISRAC2012-Rule-5.2_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.2_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.3_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.3_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.4_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.4_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.5_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.5_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.6" enabled="true" />
                                <check name="MISRAC2012-Rule-5.7" enabled="true" />
                                <check name="MISRAC2012-Rule-5.8" enabled="true" />
                                <check name="MISRAC2012-Rule-5.9" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-6">
                                <check name="MISRAC2012-Rule-6.1" enabled="true" />
                                <check name="MISRAC2012-Rule-6.2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-7">
                                <check name="MISRAC2012-Rule-7.1" enabled="true" />
                                <check name="MISRAC2012-Rule-7.2" enabled="true" />
                                <check name="MISRAC2012-Rule-7.3" enabled="true" />
                                <check name="MISRAC2012-Rule-7.4_a" enabled="true" />
                                <check name="MISRAC2012-Rule-7.4_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-8">
                                <check name="MISRAC2012-Rule-8.1" enabled="true" />
                                <check name="MISRAC2012-Rule-8.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-8.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-8.3_b" enabled="true" />
                                <check name="MISRAC2012-Rule-8.4" enabled="true" />
                                <check name="MISRAC2012-Rule-8.5_a" enabled="true" />
                                <check name="MISRAC2012-Rule-8.5_b" enabled="true" />
                                <check name="MISRAC2012-Rule-8.7" enabled="false" />
                                <check name="MISRAC2012-Rule-8.9_a" enabled="false" />
                                <check name="MISRAC2012-Rule-8.9_b" enabled="false" />
                                <check name="MISRAC2012-Rule-8.10" enabled="true" />
                                <check name="MISRAC2012-Rule-8.11" enabled="false" />
                                <check name="MISRAC2012-Rule-8.12" enabled="true" />
                                <check name="MISRAC2012-Rule-8.13" enabled="false" />
                                <check name="MISRAC2012-Rule-8.14" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-9">
                                <check name="MISRAC2012-Rule-9.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_c" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_d" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_e" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_f" enabled="true" />
                                <check name="MISRAC2012-Rule-9.2" enabled="true" />
                                <check name="MISRAC2012-Rule-9.3" enabled="true" />
                                <check name="MISRAC2012-Rule-9.4" enabled="true" />
                                <check name="MISRAC2012-Rule-9.5_a" enabled="true" />
                                <check name="MISRAC2012-Rule-9.5_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-10">
                                <check name="MISRAC2012-Rule-10.1_R2" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R3" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R4" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R5" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R6" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R7" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R8" enabled="true" />
                                <check name="MISRAC2012-Rule-10.2" enabled="true" />
                                <check name="MISRAC2012-Rule-10.3" enabled="true" />
                                <check name="MISRAC2012-Rule-10.4_a" enabled="true" />
                                <check name="MISRAC2012-Rule-10.4_b" enabled="true" />
                                <check name="MISRAC2012-Rule-10.5" enabled="false" />
                                <check name="MISRAC2012-Rule-10.6" enabled="true" />
                                <check name="MISRAC2012-Rule-10.7" enabled="true" />
                                <check name="MISRAC2012-Rule-10.8" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-11">
                                <check name="MISRAC2012-Rule-11.1" enabled="true" />
                                <check name="MISRAC2012-Rule-11.2" enabled="true" />
                                <check name="MISRAC2012-Rule-11.3" enabled="true" />
                                <check name="MISRAC2012-Rule-11.4" enabled="false" />
                                <check name="MISRAC2012-Rule-11.5" enabled="false" />
                                <check name="MISRAC2012-Rule-11.6" enabled="true" />
                                <check name="MISRAC2012-Rule-11.7" enabled="true" />
                                <check name="MISRAC2012-Rule-11.8" enabled="true" />
                                <check name="MISRAC2012-Rule-11.9" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-12">
                                <check name="MISRAC2012-Rule-12.1" enabled="false" />
                                <check name="MISRAC2012-Rule-12.2" enabled="true" />
                                <check name="MISRAC2012-Rule-12.3" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-13">
                                <check name="MISRAC2012-Rule-13.1" enabled="true" />
                                <check name="MISRAC2012-Rule-13.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-13.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-13.2_c" enabled="true" />
                                <check name="MISRAC2012-Rule-13.3" enabled="false" />
                                <check name="MISRAC2012-Rule-13.4_a" enabled="false" />
                                <check name="MISRAC2012-Rule-13.4_b" enabled="false" />
                                <check name="MISRAC2012-Rule-13.5" enabled="true" />
                                <check name="MISRAC2012-Rule-13.6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-14">
                                <check name="MISRAC2012-Rule-14.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-14.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-14.2" enabled="true" />
                                <check name="MISRAC2012-Rule-14.3_a" enabled="true" />
                                <check name="MISRAC2012-Rule-14.3_b" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_a" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_b" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_c" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_d" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-15">
                                <check name="MISRAC2012-Rule-15.1" enabled="false" />
                                <check name="MISRAC2012-Rule-15.2" enabled="true" />
                                <check name="MISRAC2012-Rule-15.3" enabled="true" />
                                <check name="MISRAC2012-Rule-15.4" enabled="false" />
                                <check name="MISRAC2012-Rule-15.5" enabled="false" />
                                <check name="MISRAC2012-Rule-15.6_a" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_b" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_c" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_d" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_e" enabled="true" />
                                <check name="MISRAC2012-Rule-15.7" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-16">
                                <check name="MISRAC2012-Rule-16.1" enabled="true" />
                                <check name="MISRAC2012-Rule-16.2" enabled="true" />
                                <check name="MISRAC2012-Rule-16.3" enabled="true" />
                                <check name="MISRAC2012-Rule-16.4" enabled="true" />
                                <check name="MISRAC2012-Rule-16.5" enabled="true" />
                                <check name="MISRAC2012-Rule-16.6" enabled="true" />
                                <check name="MISRAC2012-Rule-16.7" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-17">
                                <check name="MISRAC2012-Rule-17.1" enabled="true" />
                                <check name="MISRAC2012-Rule-17.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-17.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-17.3" enabled="true" />
                                <check name="MISRAC2012-Rule-17.4" enabled="true" />
                                <check name="MISRAC2012-Rule-17.5" enabled="false" />
                                <check name="MISRAC2012-Rule-17.6" enabled="true" />
                                <check name="MISRAC2012-Rule-17.7" enabled="true" />
                                <check name="MISRAC2012-Rule-17.8" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-18">
                                <check name="MISRAC2012-Rule-18.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-18.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-18.1_c" enabled="true" />
                                <check name="MISRAC2012-Rule-18.1_d" enabled="true" />
                                <check name="MISRAC2012-Rule-18.2" enabled="true" />
                                <check name="MISRAC2012-Rule-18.3" enabled="true" />
                                <check name="MISRAC2012-Rule-18.4" enabled="true" />
                                <check name="MISRAC2012-Rule-18.5" enabled="false" />
                                <check name="MISRAC2012-Rule-18.6_a" enabled="true" />
                                <check name="MISRAC2012-Rule-18.6_b" enabled="true" />
                                <check name="MISRAC2012-Rule-18.6_c" enabled="true" />
                                <check name="MISRAC2012-Rule-18.6_d" enabled="true" />
                                <check name="MISRAC2012-Rule-18.7" enabled="true" />
                                <check name="MISRAC2012-Rule-18.8" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-19">
                                <check name="MISRAC2012-Rule-19.1" enabled="true" />
                                <check name="MISRAC2012-Rule-19.2" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-20">
                                <check name="MISRAC2012-Rule-20.1" enabled="false" />
                                <check name="MISRAC2012-Rule-20.2" enabled="true" />
                                <check name="MISRAC2012-Rule-20.4_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-20.4_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-20.5" enabled="false" />
                                <check name="MISRAC2012-Rule-20.7" enabled="true" />
                                <check name="MISRAC2012-Rule-20.10" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-21">
                                <check name="MISRAC2012-Rule-21.1" enabled="true" />
                                <check name="MISRAC2012-Rule-21.2" enabled="true" />
                                <check name="MISRAC2012-Rule-21.3" enabled="true" />
                                <check name="MISRAC2012-Rule-21.4" enabled="true" />
                                <check name="MISRAC2012-Rule-21.5" enabled="true" />
                                <check name="MISRAC2012-Rule-21.6" enabled="true" />
                                <check name="MISRAC2012-Rule-21.7" enabled="true" />
                                <check name="MISRAC2012-Rule-21.8" enabled="true" />
                                <check name="MISRAC2012-Rule-21.9" enabled="true" />
                                <check name="MISRAC2012-Rule-21.10" enabled="true" />
                                <check name="MISRAC2012-Rule-21.11" enabled="true" />
                                <check name="MISRAC2012-Rule-21.12_a" enabled="false" />
                                <check name="MISRAC2012-Rule-21.12_b" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-22">
                                <check name="MISRAC2012-Rule-22.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-22.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-22.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-22.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-22.2_c" enabled="true" />
                                <check name="MISRAC2012-Rule-22.3" enabled="true" />
                                <check name="MISRAC2012-Rule-22.4" enabled="true" />
                                <check name="MISRAC2012-Rule-22.5_a" enabled="true" />
                                <check name="MISRAC2012-Rule-22.5_b" enabled="true" />
                                <check name="MISRAC2012-Rule-22.6" enabled="true" />
                            </group>
                        </package>
                        <package name="MISRAC++2008" enabled="false">
                            <group enabled="true" name="MISRAC++2008-0-1">
                                <check name="MISRAC++2008-0-1-1" enabled="true" />
                                <check name="MISRAC++2008-0-1-2_a" enabled="true" />
                                <check name="MISRAC++2008-0-1-2_b" enabled="true" />
                                <check name="MISRAC++2008-0-1-2_c" enabled="true" />
                                <check name="MISRAC++2008-0-1-3" enabled="true" />
                                <check name="MISRAC++2008-0-1-4_a" enabled="true" />
                                <check name="MISRAC++2008-0-1-4_b" enabled="true" />
                                <check name="MISRAC++2008-0-1-6" enabled="true" />
                                <check name="MISRAC++2008-0-1-7" enabled="true" />
                                <check name="MISRAC++2008-0-1-8" enabled="false" />
                                <check name="MISRAC++2008-0-1-9" enabled="true" />
                                <check name="MISRAC++2008-0-1-11" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-0-2">
                                <check name="MISRAC++2008-0-2-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-0-3">
                                <check name="MISRAC++2008-0-3-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-7">
                                <check name="MISRAC++2008-2-7-1" enabled="true" />
                                <check name="MISRAC++2008-2-7-2" enabled="true" />
                                <check name="MISRAC++2008-2-7-3" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-10">
                                <check name="MISRAC++2008-2-10-1" enabled="true" />
                                <check name="MISRAC++2008-2-10-2" enabled="true" />
                                <check name="MISRAC++2008-2-10-3" enabled="true" />
                                <check name="MISRAC++2008-2-10-4" enabled="true" />
                                <check name="MISRAC++2008-2-10-5" enabled="false" />
                                <check name="MISRAC++2008-2-10-6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-13">
                                <check name="MISRAC++2008-2-13-2" enabled="true" />
                                <check name="MISRAC++2008-2-13-3" enabled="true" />
                                <check name="MISRAC++2008-2-13-4_a" enabled="true" />
                                <check name="MISRAC++2008-2-13-4_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-3-1">
                                <check name="MISRAC++2008-3-1-1" enabled="true" />
                                <check name="MISRAC++2008-3-1-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-3-9">
                                <check name="MISRAC++2008-3-9-2" enabled="false" />
                                <check name="MISRAC++2008-3-9-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-4-5">
                                <check name="MISRAC++2008-4-5-1" enabled="true" />
                                <check name="MISRAC++2008-4-5-2" enabled="true" />
                                <check name="MISRAC++2008-4-5-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-0">
                                <check name="MISRAC++2008-5-0-1_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-1_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-1_c" enabled="true" />
                                <check name="MISRAC++2008-5-0-2" enabled="false" />
                                <check name="MISRAC++2008-5-0-3" enabled="true" />
                                <check name="MISRAC++2008-5-0-4" enabled="true" />
                                <check name="MISRAC++2008-5-0-5" enabled="true" />
                                <check name="MISRAC++2008-5-0-6" enabled="true" />
                                <check name="MISRAC++2008-5-0-7" enabled="true" />
                                <check name="MISRAC++2008-5-0-8" enabled="true" />
                                <check name="MISRAC++2008-5-0-9" enabled="true" />
                                <check name="MISRAC++2008-5-0-10" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_c" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_d" enabled="true" />
                                <check name="MISRAC++2008-5-0-14" enabled="true" />
                                <check name="MISRAC++2008-5-0-15_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-15_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_c" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_d" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_e" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_f" enabled="true" />
                                <check name="MISRAC++2008-5-0-19" enabled="true" />
                                <check name="MISRAC++2008-5-0-21" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-2">
                                <check name="MISRAC++2008-5-2-4" enabled="true" />
                                <check name="MISRAC++2008-5-2-5" enabled="true" />
                                <check name="MISRAC++2008-5-2-6" enabled="true" />
                                <check name="MISRAC++2008-5-2-7" enabled="true" />
                                <check name="MISRAC++2008-5-2-9" enabled="false" />
                                <check name="MISRAC++2008-5-2-10" enabled="false" />
                                <check name="MISRAC++2008-5-2-11_a" enabled="true" />
                                <check name="MISRAC++2008-5-2-11_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-3">
                                <check name="MISRAC++2008-5-3-1" enabled="true" />
                                <check name="MISRAC++2008-5-3-2_a" enabled="true" />
                                <check name="MISRAC++2008-5-3-2_b" enabled="true" />
                                <check name="MISRAC++2008-5-3-3" enabled="true" />
                                <check name="MISRAC++2008-5-3-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-8">
                                <check name="MISRAC++2008-5-8-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-14">
                                <check name="MISRAC++2008-5-14-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-18">
                                <check name="MISRAC++2008-5-18-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-19">
                                <check name="MISRAC++2008-5-19-1" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-2">
                                <check name="MISRAC++2008-6-2-1" enabled="true" />
                                <check name="MISRAC++2008-6-2-2" enabled="true" />
                                <check name="MISRAC++2008-6-2-3" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-3">
                                <check name="MISRAC++2008-6-3-1_a" enabled="true" />
                                <check name="MISRAC++2008-6-3-1_b" enabled="true" />
                                <check name="MISRAC++2008-6-3-1_c" enabled="true" />
                                <check name="MISRAC++2008-6-3-1_d" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-4">
                                <check name="MISRAC++2008-6-4-1" enabled="true" />
                                <check name="MISRAC++2008-6-4-2" enabled="true" />
                                <check name="MISRAC++2008-6-4-3" enabled="true" />
                                <check name="MISRAC++2008-6-4-4" enabled="true" />
                                <check name="MISRAC++2008-6-4-5" enabled="true" />
                                <check name="MISRAC++2008-6-4-6" enabled="true" />
                                <check name="MISRAC++2008-6-4-7" enabled="true" />
                                <check name="MISRAC++2008-6-4-8" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-5">
                                <check name="MISRAC++2008-6-5-1_a" enabled="true" />
                                <check name="MISRAC++2008-6-5-2" enabled="true" />
                                <check name="MISRAC++2008-6-5-3" enabled="true" />
                                <check name="MISRAC++2008-6-5-4" enabled="true" />
                                <check name="MISRAC++2008-6-5-6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-6">
                                <check name="MISRAC++2008-6-6-1" enabled="true" />
                                <check name="MISRAC++2008-6-6-2" enabled="true" />
                                <check name="MISRAC++2008-6-6-4" enabled="true" />
                                <check name="MISRAC++2008-6-6-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-1">
                                <check name="MISRAC++2008-7-1-1" enabled="true" />
                                <check name="MISRAC++2008-7-1-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-2">
                                <check name="MISRAC++2008-7-2-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-4">
                                <check name="MISRAC++2008-7-4-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-5">
                                <check name="MISRAC++2008-7-5-1_a" enabled="true" />
                                <check name="MISRAC++2008-7-5-1_b" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_a" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_b" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_c" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_d" enabled="true" />
                                <check name="MISRAC++2008-7-5-4_a" enabled="false" />
                                <check name="MISRAC++2008-7-5-4_b" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-0">
                                <check name="MISRAC++2008-8-0-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-4">
                                <check name="MISRAC++2008-8-4-1" enabled="true" />
                                <check name="MISRAC++2008-8-4-3" enabled="true" />
                                <check name="MISRAC++2008-8-4-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-5">
                                <check name="MISRAC++2008-8-5-1_a" enabled="true" />
                                <check name="MISRAC++2008-8-5-1_b" enabled="true" />
                                <check name="MISRAC++2008-8-5-1_c" enabled="true" />
                                <check name="MISRAC++2008-8-5-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-3">
                                <check name="MISRAC++2008-9-3-1" enabled="true" />
                                <check name="MISRAC++2008-9-3-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-5">
                                <check name="MISRAC++2008-9-5-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-6">
                                <check name="MISRAC++2008-9-6-2" enabled="true" />
                                <check name="MISRAC++2008-9-6-3" enabled="true" />
                                <check name="MISRAC++2008-9-6-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-12-1">
                                <check name="MISRAC++2008-12-1-1_a" enabled="true" />
                                <check name="MISRAC++2008-12-1-1_b" enabled="true" />
                                <check name="MISRAC++2008-12-1-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-0">
                                <check name="MISRAC++2008-15-0-2" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-1">
                                <check name="MISRAC++2008-15-1-2" enabled="true" />
                                <check name="MISRAC++2008-15-1-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-3">
                                <check name="MISRAC++2008-15-3-1" enabled="true" />
                                <check name="MISRAC++2008-15-3-2" enabled="false" />
                                <check name="MISRAC++2008-15-3-3" enabled="true" />
                                <check name="MISRAC++2008-15-3-4" enabled="true" />
                                <check name="MISRAC++2008-15-3-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-5">
                                <check name="MISRAC++2008-15-5-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-0">
                                <check name="MISRAC++2008-16-0-3" enabled="true" />
                                <check name="MISRAC++2008-16-0-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-2">
                                <check name="MISRAC++2008-16-2-2" enabled="true" />
                                <check name="MISRAC++2008-16-2-3" enabled="true" />
                                <check name="MISRAC++2008-16-2-4" enabled="true" />
                                <check name="MISRAC++2008-16-2-5" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-3">
                                <check name="MISRAC++2008-16-3-1" enabled="true" />
                                <check name="MISRAC++2008-16-3-2" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-17-0">
                                <check name="MISRAC++2008-17-0-1" enabled="true" />
                                <check name="MISRAC++2008-17-0-3" enabled="true" />
                                <check name="MISRAC++2008-17-0-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-0">
                                <check name="MISRAC++2008-18-0-1" enabled="true" />
                                <check name="MISRAC++2008-18-0-2" enabled="true" />
                                <check name="MISRAC++2008-18-0-3" enabled="true" />
                                <check name="MISRAC++2008-18-0-4" enabled="true" />
                                <check name="MISRAC++2008-18-0-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-2">
                                <check name="MISRAC++2008-18-2-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-4">
                                <check name="MISRAC++2008-18-4-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-7">
                                <check name="MISRAC++2008-18-7-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-19-3">
                                <check name="MISRAC++2008-19-3-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-27-0">
                                <check name="MISRAC++2008-27-0-1" enabled="true" />
                            </group>
                        </package>
                    </checks_tree>
                </cstat_settings>
            </data>
        </settings>
        <settings>
            <name>RuntimeChecking</name>
            <archiveVersion>0</archiveVersion>
            <data>
                <version>2</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>GenRtcDebugHeap</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcEnableBoundsChecking</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcCheckPtrsNonInstrMem</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcTrackPointerBounds</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcCheckAccesses</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcGenerateEntries</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcNrTrackedPointers</name>
                    <state>1000</state>
                </option>
                <option>
                    <name>GenRtcIntOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIncUnsigned</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIntConversion</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcInclExplicit</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIntShiftOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcInclUnsignedShiftOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcUnhandledCase</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcDivByZero</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcEnable</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcCheckPtrsNonInstrFunc</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
    </configuration>
    <group>
        <name>App</name>
        <group>
            <name>knowledgepack</name>
            <group>
                <name>inc</name>
                <file>
                    <name>$PROJ_DIR$\..\knowledgepack\inc\sml_recognition_config.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\knowledgepack\inc\sml_recognition_run.h</name>
                </file>
            </group>
            <group>
                <name>sensiml</name>
                <group>
                    <name>inc</name>
                    <file>
                        <name>$PROJ_DIR$\..\knowledgepack\sensiml\inc\kb.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\knowledgepack\sensiml\inc\kb_defines.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\knowledgepack\sensiml\inc\kb_typedefs.h</name>
                    </file>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\knowledgepack\sensiml\libsensiml.a</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\knowledgepack\sensiml\model.json</name>
                </file>
            </group>
            <group>
                <name>src</name>
                <file>
                    <name>$PROJ_DIR$\..\knowledgepack\src\sml_recognition_run.c</name>
                </file>
            </group>
        </group>
        <group>
            <name>qf_mqttsn_ai_app</name>
            <group>
                <name>ad7476</name>
                <group>
                    <name>inc</name>
                    <file>
                        <name>$PROJ_DIR$\..\ad7476\inc\sensor_ad7476_acquisition.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\ad7476\inc\sensor_ad7476_config.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\ad7476\inc\sensor_ad7476_config_user.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\ad7476\inc\sensor_ad7476_process.h</name>
                    </file>
                </group>
                <group>
                    <name>src</name>
                    <file>
                        <name>$PROJ_DIR$\..\ad7476\src\sensor_ad7476_acquisition.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\ad7476\src\sensor_ad7476_acquisition_test.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\ad7476\src\sensor_ad7476_config.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\ad7476\src\sensor_ad7476_process.c</name>
                    </file>
                </group>
            </group>
            <group>
                <name>fsm</name>
                <file>
                    <name>$PROJ_DIR$\..\fsm\fsm.h</name>
                </file>
            </group>
            <group>
                <name>imu</name>
                <group>
                    <name>inc</name>
                    <file>
                        <name>$PROJ_DIR$\..\imu\inc\sensor_imu_acquisition.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\imu\inc\sensor_imu_config.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\imu\inc\sensor_imu_config_user.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\imu\inc\sensor_imu_process.h</name>
                    </file>
                </group>
                <group>
                    <name>src</name>
                    <file>
                        <name>$PROJ_DIR$\..\imu\src\sensor_imu_acquisition.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\imu\src\sensor_imu_acquisition_test.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\imu\src\sensor_imu_config.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\imu\src\sensor_imu_config_private.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\imu\src\sensor_imu_process.c</name>
                    </file>
                </group>
            </group>
            <group>
                <name>inc</name>
                <file>
                    <name>$PROJ_DIR$\..\inc\Bootconfig.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\inc\DataCollection.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\inc\FreeRTOSConfig.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\inc\FreeRTOSFATConfig.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\inc\Fw_global_config.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\inc\Fw_task.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\inc\mqttsn_comm.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\src\mqttsn_uart.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\inc\ql_fs.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\inc\RtosTask.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\inc\s3x_pwrcfg.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\inc\sec_debug.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\inc\sensor_cmds.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\inc\sml_output.h</name>
                </file>
            </group>
            <group>
                <name>IOP_MQTTSN</name>
                <group>
                    <name>inc</name>
                    <file>
                        <name>$PROJ_DIR$\..\IOP_MQTTSN\inc\ble_collection_defs.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\IOP_MQTTSN\inc\ble_pme_defs.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\IOP_MQTTSN\inc\dcl_commands.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\IOP_MQTTSN\inc\iop_messages.h</name>
                    </file>
                </group>
                <group>
                    <name>src</name>
                </group>
            </group>
            <group>
                <name>sensor_audio</name>
                <group>
                    <name>inc</name>
                    <file>
                        <name>$PROJ_DIR$\..\sensor_audio\inc\sensor_audio_acquisition.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\sensor_audio\inc\sensor_audio_config.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\sensor_audio\inc\sensor_audio_config_user.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\sensor_audio\inc\sensor_audio_process.h</name>
                    </file>
                </group>
                <group>
                    <name>src</name>
                    <file>
                        <name>$PROJ_DIR$\..\sensor_audio\src\sensor_audio_acquisition.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\sensor_audio\src\sensor_audio_acquisition_test.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\sensor_audio\src\sensor_audio_config.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\sensor_audio\src\sensor_audio_process.c</name>
                    </file>
                </group>
            </group>
            <group>
                <name>src</name>
                <file>
                    <name>$PROJ_DIR$\..\src\ble_app.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\src\c_lib_retarget.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\src\datasave.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\src\exceptions.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\src\main.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\src\main_dbg_cli_menu.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\src\mqttsn_comm.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\src\mqttsn_uart.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\src\pincfg_table.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\src\process_imu.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\src\qf_hardwaresetup.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\src\Recognition.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\src\s3x_pwrcfg.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\src\sec_debug.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\src\Sensor_Attributes.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\src\sensor_config.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\src\sensor_data_task.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\src\sml_output.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\src\watchdog.c</name>
                </file>
            </group>
        </group>
    </group>
    <group>
        <name>BSP</name>
        <group>
            <name>quickfeather</name>
            <group>
                <name>inc</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\BSP\quickfeather\inc\leds.h</name>
                </file>
            </group>
            <group>
                <name>src</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\BSP\quickfeather\src\qf_hardwaresetup.c</name>
                </file>
            </group>
        </group>
    </group>
    <group>
        <name>FreeRTOS</name>
        <group>
            <name>include</name>
            <group>
                <name>portable</name>
                <group>
                    <name>IAR</name>
                    <group>
                        <name>ARM_CM4F_quicklogic_s3XX</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\..\FreeRTOS\portable\IAR\ARM_CM4F_quicklogic_s3XX\port.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\..\FreeRTOS\portable\IAR\ARM_CM4F_quicklogic_s3XX\portasm.s</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\..\FreeRTOS\portable\IAR\ARM_CM4F_quicklogic_s3XX\portmacro.h</name>
                        </file>
                    </group>
                </group>
                <group>
                    <name>MemMang</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\FreeRTOS\portable\MemMang\heap_4.c</name>
                    </file>
                </group>
            </group>
            <file>
                <name>$PROJ_DIR$\..\..\..\FreeRTOS\include\croutine.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\FreeRTOS\include\deprecated_definitions.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\FreeRTOS\include\event_groups.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\FreeRTOS\include\FreeRTOS.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\FreeRTOS\include\FreeRTOSConfig.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\FreeRTOS\include\list.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\FreeRTOS\include\message_buffer.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\FreeRTOS\include\mpu_prototypes.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\FreeRTOS\include\mpu_wrappers.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\FreeRTOS\include\portable.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\FreeRTOS\include\projdefs.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\FreeRTOS\include\queue.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\FreeRTOS\include\semphr.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\FreeRTOS\include\stack_macros.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\FreeRTOS\include\StackMacros.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\FreeRTOS\include\stdint.readme</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\FreeRTOS\include\stream_buffer.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\FreeRTOS\include\task.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\FreeRTOS\include\timers.h</name>
            </file>
        </group>
        <file>
            <name>$PROJ_DIR$\..\..\..\FreeRTOS\croutine.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\FreeRTOS\event_groups.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\FreeRTOS\freertos_static_memory.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\FreeRTOS\list.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\FreeRTOS\queue.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\FreeRTOS\readme.txt</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\FreeRTOS\stream_buffer.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\FreeRTOS\tasks.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\FreeRTOS\timers.c</name>
        </file>
    </group>
    <group>
        <name>freertos_gateware</name>
        <group>
            <name>inc</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\freertos_gateware\inc\eoss3_hal_fpga_ad7476_reg.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\freertos_gateware\inc\eoss3_hal_fpga_adc_api.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\freertos_gateware\inc\eoss3_hal_fpga_clk_sync.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\freertos_gateware\inc\eoss3_hal_fpga_gpio.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\freertos_gateware\inc\eoss3_hal_fpga_ltc1859_reg.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\freertos_gateware\inc\eoss3_hal_fpga_sdma_api.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\freertos_gateware\inc\eoss3_hal_fpga_sdma_reg.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\freertos_gateware\inc\eoss3_hal_fpga_uart.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\freertos_gateware\inc\eoss3_hal_fpga_usbserial.h</name>
            </file>
        </group>
        <group>
            <name>src</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\freertos_gateware\src\eoss3_hal_fpga_ad7476.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\freertos_gateware\src\eoss3_hal_fpga_clk_sync.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\freertos_gateware\src\eoss3_hal_fpga_gpio.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\freertos_gateware\src\eoss3_hal_fpga_ltc1859.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\freertos_gateware\src\eoss3_hal_fpga_sdma.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\freertos_gateware\src\eoss3_hal_fpga_uart.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\freertos_gateware\src\eoss3_hal_fpga_usbserial.c</name>
            </file>
        </group>
    </group>
    <group>
        <name>HAL</name>
        <group>
            <name>inc</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_api.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_dev.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_adc.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_audio.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_audio_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_audio_reg.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_def.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_ffe.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_gpio.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_i2c.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_i2s.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_i2s_drv.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_leds.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_pad_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_pads.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_pkfb.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_pmu_timer.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_rtc.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_sdma.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_spi-p4org.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_spi.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_timer.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_uart.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_wb.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\eoss3_hal_wdt.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\s3x_clock_hal.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\inc\test_types.h</name>
            </file>
        </group>
        <group>
            <name>src</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\src\eoss3_hal_adc.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\src\eoss3_hal_audio.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\src\eoss3_hal_ffe.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\src\eoss3_hal_gpio.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\src\eoss3_hal_i2c.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\src\eoss3_hal_i2s.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\src\eoss3_hal_i2s_master_assp.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\src\eoss3_hal_i2s_slave_assp.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\src\eoss3_hal_pad_config.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\src\eoss3_hal_pkfb.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\src\eoss3_hal_rtc.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\src\eoss3_hal_sdma.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\src\eoss3_hal_spi.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\src\eoss3_hal_timer.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\src\eoss3_hal_uart.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\src\eoss3_hal_wb.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\src\eoss3_hal_wdt.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\src\s3x_clock_hal.c</name>
            </file>
        </group>
        <group>
            <name>startup</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\startup\startup_EOSS3B_IAR.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\HAL\startup\vectors_CM4F_iar.c</name>
            </file>
        </group>
    </group>
    <group>
        <name>Libraries</name>
        <group>
            <name>cli</name>
            <group>
                <name>inc</name>
                <group>
                    <name>cli</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\cli\inc\cli\cli_args.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\cli\inc\cli\cli_filesystem.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\cli\inc\cli\cli_getkey.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\cli\inc\cli\cli_hw.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\cli\inc\cli\cli_misc.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\cli\inc\cli\cli_print.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\cli\inc\cli\cli_structs.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\cli\inc\cli\cli_time.h</name>
                    </file>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\cli\inc\cli.h</name>
                </file>
            </group>
            <group>
                <name>src</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\cli\src\cli_args.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\cli\src\cli_filesystem.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\cli\src\cli_fsminterface.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\cli\src\cli_hexdump.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\cli\src\cli_io.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\cli\src\cli_loop.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\cli\src\cli_misc.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\cli\src\cli_platform.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\cli\src\cli_stdcmds.c</name>
                </file>
            </group>
        </group>
        <group>
            <name>CMSIS</name>
            <group>
                <name>DSP</name>
                <group>
                    <name>src</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\src\arm_bitreversal2.S</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\src\arm_cfft_f32.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\src\arm_cfft_radix8_f32.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\src\arm_common_tables.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\src\arm_const_structs.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\src\arm_dot_prod_f32.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\src\arm_rfft_fast_f32.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\src\arm_rfft_fast_init_f32.c</name>
                    </file>
                    <configuration>
                        <name>Debug</name>
                    </configuration>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS_5\CMSIS\DSP\Lib\IAR\arm_cortexM_math.a</name>
                </file>
            </group>
            <group>
                <name>math</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\src\arm_add_q15.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\src\arm_mult_q15.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\src\arm_negate_q15.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\src\arm_offset_q15.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\src\arm_shift_q15.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\src\arm_sub_q15.c</name>
                </file>
            </group>
            <group>
                <name>NN</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\src\arm_fully_connected_mat_q7_vec_q15_opt.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\src\arm_nn_activations_q15.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\src\arm_nntables.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\src\arm_q15_to_float.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\src\arm_relu_q15.c</name>
                </file>
            </group>
            <configuration>
                <name>Debug</name>
            </configuration>
        </group>
        <group>
            <name>DatablockManager</name>
            <group>
                <name>inc</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\DatablockManager\inc\datablk_mgr.h</name>
                </file>
            </group>
            <group>
                <name>src</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\DatablockManager\src\datablk_mgr.c</name>
                </file>
            </group>
        </group>
        <group>
            <name>FPGA</name>
            <group>
                <name>inc</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FPGA\inc\fpga_loader.h</name>
                </file>
            </group>
            <group>
                <name>src</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FPGA\src\fpga_loader.c</name>
                </file>
            </group>
        </group>
        <group>
            <name>FreeRTOS_FAT</name>
            <group>
                <name>include</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\include\ff_crc.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\include\ff_devices.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\include\ff_dir.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\include\ff_error.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\include\ff_fat.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\include\ff_fatdef.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\include\ff_file.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\include\ff_format.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\include\ff_headers.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\include\ff_ioman.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\include\ff_locking.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\include\ff_memory.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\include\ff_old_config_defines.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\include\ff_stdio.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\include\ff_string.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\include\ff_sys.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\include\ff_time.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\include\FreeRTOS_errno_FAT.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\include\FreeRTOSFATConfig.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\include\FreeRTOSFATConfigDefaults.h</name>
                </file>
            </group>
            <group>
                <name>portable</name>
                <group>
                    <name>common</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\portable\common\ff_ramdisk.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\portable\common\ff_ramdisk.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\portable\common\ff_sddisk.h</name>
                    </file>
                </group>
                <group>
                    <name>QL</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\portable\QL\ff_test_apis.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\portable\QL\media_drv_spi.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\portable\QL\media_drv_spi.h</name>
                    </file>
                </group>
            </group>
            <file>
                <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\ff_crc.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\ff_dir.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\ff_error.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\ff_fat.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\ff_file.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\ff_format.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\ff_ioman.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\ff_locking.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\ff_memory.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\ff_stdio.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\ff_string.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\ff_sys.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\ff_time.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\Libraries\FreeRTOS_FAT\History.txt</name>
            </file>
        </group>
        <group>
            <name>MQTTSN</name>
            <group>
                <name>inc</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN\inc\MQTTSNConnect.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN\inc\MQTTSNPacket.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN\inc\MQTTSNPublish.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN\inc\MQTTSNSearch.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN\inc\MQTTSNSubscribe.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN\inc\MQTTSNUnsubscribe.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN\inc\StackTrace.h</name>
                </file>
            </group>
            <group>
                <name>src</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN\src\MQTTSNConnectClient.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN\src\MQTTSNConnectServer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN\src\MQTTSNDeserializePublish.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN\src\MQTTSNPacket.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN\src\MQTTSNSearchClient.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN\src\MQTTSNSerializePublish.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN\src\MQTTSNSubscribeClient.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN\src\MQTTSNUnsubscribeClient.c</name>
                </file>
            </group>
        </group>
        <group>
            <name>MQTTSN_SML</name>
            <group>
                <name>inc</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN_SML\inc\Mqttsn_App.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN_SML\inc\Mqttsn_CliCmds.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN_SML\inc\Mqttsn_MessageHandler.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN_SML\inc\Mqttsn_Topics.h</name>
                </file>
            </group>
            <group>
                <name>src</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN_SML\src\MajorTopicDispatch.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN_SML\src\MinorTopicDispatch_Collect.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN_SML\src\MinorTopicDispatch_Live.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN_SML\src\MinorTopicDispatch_Recog.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN_SML\src\MinorTopicDispatch_Sensor.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN_SML\src\MinorTopicDispatch_Storage.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN_SML\src\MinorTopicDispatch_System.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN_SML\src\Mqttsn_App.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN_SML\src\Mqttsn_CliCmds.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN_SML\src\Mqttsn_MsgHandler.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\MQTTSN_SML\src\Mqttsn_Topics.c</name>
                </file>
            </group>
        </group>
        <group>
            <name>Power</name>
            <group>
                <name>inc</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Power\inc\s3x_clock.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Power\inc\s3x_cpuload.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Power\inc\s3x_dfs.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Power\inc\s3x_err_base.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Power\inc\s3x_lpm.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Power\inc\s3x_pi.h</name>
                </file>
            </group>
            <group>
                <name>src</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Power\src\s3x_clock.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Power\src\s3x_cpuload.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Power\src\s3x_dfs.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Power\src\s3x_lpm.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Power\src\s3x_pi.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Power\src\s3x_qos.c</name>
                </file>
            </group>
        </group>
        <group>
            <name>QLFS</name>
            <group>
                <name>inc</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\QLFS\inc\media_drv_defines.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\QLFS\inc\media_drv_spi_sd.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\QLFS\inc\mmc_s3.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\QLFS\inc\ql_fs.h</name>
                </file>
            </group>
            <group>
                <name>src</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\QLFS\src\freeRTOSFs_test.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\QLFS\src\media_drv_spi_sd.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\QLFS\src\mmc_s3.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\QLFS\src\ql_fs.c</name>
                </file>
            </group>
        </group>
        <group>
            <name>QLRC</name>
            <group>
                <name>inc</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\QLSRC\inc\QL_InterpBy3.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\QLSRC\inc\TypeDefs.h</name>
                </file>
            </group>
            <group>
                <name>src</name>
            </group>
        </group>
        <group>
            <name>QLSPI</name>
            <group>
                <name>inc</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\QLSPI\inc\qlspi_fw_loader.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\QLSPI\inc\qlspi_s3.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\QLSPI\inc\tlc_reg.h</name>
                </file>
            </group>
            <group>
                <name>src</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\QLSPI\src\qlspi_fw_loader.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\QLSPI\src\qlspi_s3.c</name>
                </file>
            </group>
        </group>
        <group>
            <name>riff_files</name>
            <group>
                <name>inc</name>
                <group>
                    <name>riff_files</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\riff_file\inc\riff_file\riff_block_pool.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\riff_file\inc\riff_file\riff_file.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\riff_file\inc\riff_file\riff_misc.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\riff_file\inc\riff_file\riff_writer.h</name>
                    </file>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\riff_file\inc\ql_riff.h</name>
                </file>
            </group>
            <group>
                <name>src</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\riff_file\src\riff_block_pool.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\riff_file\src\riff_file.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\riff_file\src\riff_internal.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\riff_file\src\riff_misc.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\riff_file\src\riff_writer.c</name>
                </file>
            </group>
        </group>
        <group>
            <name>SensorFramework</name>
            <group>
                <name>drivers</name>
                <group>
                    <name>FFE</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\drivers\FFE\Accel2_FFE_Drv.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\drivers\FFE\Accel_ffe_drv.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\drivers\FFE\DT_FFE_Drv.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\drivers\FFE\Gyro_FFE_Drv.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\drivers\FFE\Mag_FFE_Drv.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\drivers\FFE\Sensiml_ffe_drv.c</name>
                    </file>
                </group>
                <group>
                    <name>inc</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\drivers\inc\QL_SDF_Accel.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\drivers\inc\QL_SDF_Gyro.h</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\drivers\inc\QL_SDF_Mag.h</name>
                    </file>
                </group>
                <group>
                    <name>M4</name>
                    <group>
                        <name>BMI160</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\drivers\M4\BMI160\Accel_BMI160.c</name>
                        </file>
                    </group>
                    <group>
                        <name>LSM6DSL</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\drivers\M4\LSM6DSL\Accel_LSM6DSL.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\drivers\M4\LSM6DSL\Gyro_LSM6DSL.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\drivers\M4\LSM6DSL\LSM6DSL.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\drivers\M4\LSM6DSL\LSM6DSL_Accel.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\drivers\M4\LSM6DSL\LSM6DSL_Gyro.h</name>
                        </file>
                    </group>
                    <group>
                        <name>mc3635</name>
                        <file>
                            <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\drivers\M4\mc3635\mc3635.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\drivers\M4\mc3635\mc3635.h</name>
                        </file>
                    </group>
                </group>
            </group>
            <group>
                <name>inc</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\inc\ffe_ipc_lib.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\inc\QL_FFE_SensorConfig.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\inc\QL_SAL.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\inc\QL_SDF.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\inc\QL_SensorCommon.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\inc\ql_SensorHub_MemoryMap.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\inc\QL_SensorIoctl.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\inc\QL_Trace.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\inc\qlsh_commands.h</name>
                </file>
            </group>
            <group>
                <name>lib</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\lib\ffe_export_section.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\lib\ffe_ipc_lib.c</name>
                </file>
            </group>
            <group>
                <name>src</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\src\QL_SensorFramework.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\SensorFramework\src\QL_Trace.c</name>
                </file>
            </group>
        </group>
        <group>
            <name>SysFlash</name>
            <group>
                <name>inc</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\SysFlash\inc\spi_flash.h</name>
                </file>
            </group>
            <group>
                <name>src</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\SysFlash\src\spi_flash.c</name>
                </file>
            </group>
        </group>
        <group>
            <name>Utils</name>
            <group>
                <name>inc</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Utils\inc\common.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Utils\inc\crc16.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Utils\inc\crc32.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Utils\inc\dbg_queue_monitor.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Utils\inc\dbg_uart.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Utils\inc\micro_tick64.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Utils\inc\ql_time.h</name>
                </file>
            </group>
            <group>
                <name>src</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Utils\src\crc16.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Utils\src\crc32.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Utils\src\dbg_queue_monitor.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Utils\src\dbg_uart.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Utils\src\dbgtrace.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Utils\src\micro_tick64.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Libraries\Utils\src\ql_time.c</name>
                </file>
            </group>
        </group>
    </group>
    <group>
        <name>s3-gateware</name>
        <group>
            <name>ad7476</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\s3-gateware\adc_ad7476_if\src\fpga.c</name>
            </file>
        </group>
        <group>
            <name>usb2serial</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\s3-gateware\usb2serial\src\usb2serial.c</name>
            </file>
        </group>
        <file>
            <name>$PROJ_DIR$\..\..\..\s3-gateware\gateware.h</name>
        </file>
    </group>
    <group>
        <name>Tasks</name>
        <group>
            <name>ADC</name>
            <group>
                <name>inc</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Tasks\ADC\inc\ql_adcTask.h</name>
                </file>
            </group>
            <group>
                <name>src</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Tasks\ADC\src\ql_adcTask.c</name>
                </file>
            </group>
        </group>
        <group>
            <name>BLE</name>
            <group>
                <name>inc</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Tasks\BLE\inc\ql_bleTask.h</name>
                </file>
            </group>
            <group>
                <name>src</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Tasks\BLE\src\ql_bleTask.c</name>
                </file>
            </group>
        </group>
        <group>
            <name>datablk_processor</name>
            <group>
                <name>inc</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Tasks\DatablockProcessor\inc\datablk_processor.h</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Tasks\DatablockProcessor\inc\process_ids.h</name>
                </file>
            </group>
            <group>
                <name>src</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Tasks\DatablockProcessor\src\datablk_processor.c</name>
                </file>
            </group>
        </group>
        <group>
            <name>SDCard</name>
            <group>
                <name>inc</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\Tasks\SDCard\inc\ql_sdcardTask.h</name>
                </file>
            </group>
            <group>
                <name>src</name>
            </group>
        </group>
        <group>
            <name>test</name>
        </group>
    </group>
    <file>
        <name>$PROJ_DIR$\qf_mqttsn_ai_app.icf</name>
    </file>
</project>
