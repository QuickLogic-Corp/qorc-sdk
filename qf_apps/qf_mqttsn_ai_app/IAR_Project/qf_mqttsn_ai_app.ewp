# IAR project qf_mqttsn_ai_app.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __FPU_USED; __EOSS3_CHIP; __RTOS; configUSE_STATS_FORMATTING_FUNCTIONS; configUSE_TRACE_FACILITY; ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __FPU_PRESENT; __FPU_USED
  ICCARM.IExtraOptions: --aeabi; --guard_calls; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\inc; ..\ad7476\inc; ..\sensor_audio\inc; ..\knowledgepack\inc; ..\knowledgepack\sensiml\inc; ..\..\..\HAL\inc; ..\..\..\FreeRTOS\include; ..\..\..\FreeRTOS\portable\IAR\ARM_CM4F_quicklogic_s3XX; ..\..\..\Libraries\CMSIS\inc; ..\..\..\Libraries\QLFS\inc; ..\..\..\Libraries\FPGA\inc; ..\..\..\Libraries\Power\inc; ..\..\..\Libraries\QLSPI\inc; ..\..\..\Libraries\Audio\inc; ..\..\..\Libraries\Utils\inc; ..\..\..\Libraries\SysFlash\inc; ..\..\..\Libraries\CMSIS\DSP\Include; ..\..\..\Libraries\DatablockManager\inc; ..\..\..\Tasks\DatablockProcessor\inc; ..\..\..\Tasks\ADC\inc; ..\..\..\Libraries\FreeRTOS_FAT\include; ..\..\..\Libraries\FreeRTOS_FAT\portable\QL; ..\..\..\Libraries\MQTTSN\inc; ..\..\..\Libraries\MQTTSN_SML\inc; ..\..\..\Libraries\SensorFramework\inc; ..\..\..\Libraries\SensorFramework\drivers\M4\mc3635; ..\..\..\Libraries\cli\inc; ..\..\..\Libraries\riff_file\inc; ..\..\..\Libraries\riff_file\riff_file\inc; ..\..\..\BSP\quickfeather\inc; ..\..\..\s3-gateware; ..\fsm; ..\..\..\freertos_gateware\inc; ..\IOP_MQTTSN\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\inc; ..\..\..\FreeRTOS\include
  OBJCOPY.OOCOutputFile: qf_mqttsn_ai_app.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: qf_mqttsn_ai_app.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: qf_mqttsn_ai_app.icf
  group App/knowledgepack/inc
    ../knowledgepack/inc/: sml_recognition_config.h sml_recognition_run.h
  group App/knowledgepack/sensiml
    ../knowledgepack/sensiml/: libsensiml.a model.json
  group App/knowledgepack/sensiml/inc
    ../knowledgepack/sensiml/inc/: kb.h kb_defines.h kb_typedefs.h
  group App/knowledgepack/src
    ../knowledgepack/src/: sml_recognition_run.c
  group App/qf_mqttsn_ai_app/ad7476/inc
    ../ad7476/inc/: sensor_ad7476_acquisition.h sensor_ad7476_config.h sensor_ad7476_config_user.h sensor_ad7476_process.h
  group App/qf_mqttsn_ai_app/ad7476/src
    ../ad7476/src/: sensor_ad7476_acquisition.c sensor_ad7476_acquisition_test.c sensor_ad7476_config.c sensor_ad7476_process.c
  group App/qf_mqttsn_ai_app/fsm
    ../fsm/: fsm.h
  group App/qf_mqttsn_ai_app/imu/inc
    ../imu/inc/: sensor_imu_acquisition.h sensor_imu_config.h sensor_imu_config_user.h sensor_imu_process.h
  group App/qf_mqttsn_ai_app/imu/src
    ../imu/src/: sensor_imu_acquisition.c sensor_imu_acquisition_test.c sensor_imu_config.c sensor_imu_config_private.c sensor_imu_process.c
  group App/qf_mqttsn_ai_app/inc
    ../inc/: Bootconfig.h DataCollection.h FreeRTOSConfig.h FreeRTOSFATConfig.h Fw_global_config.h Fw_task.h mqttsn_comm.h ql_fs.h RtosTask.h s3x_pwrcfg.h sec_debug.h sensor_cmds.h sml_output.h
    ../src/: mqttsn_uart.h
  group App/qf_mqttsn_ai_app/IOP_MQTTSN/inc
    ../IOP_MQTTSN/inc/: ble_collection_defs.h ble_pme_defs.h dcl_commands.h iop_messages.h
  group App/qf_mqttsn_ai_app/sensor_audio/inc
    ../sensor_audio/inc/: sensor_audio_acquisition.h sensor_audio_config.h sensor_audio_config_user.h sensor_audio_process.h
  group App/qf_mqttsn_ai_app/sensor_audio/src
    ../sensor_audio/src/: sensor_audio_acquisition.c sensor_audio_acquisition_test.c sensor_audio_config.c sensor_audio_process.c
  group App/qf_mqttsn_ai_app/src
    ../src/: ble_app.c c_lib_retarget.c datasave.c exceptions.c main.c main_dbg_cli_menu.c mqttsn_comm.c mqttsn_uart.c pincfg_table.c process_imu.c qf_hardwaresetup.c Recognition.c s3x_pwrcfg.c sec_debug.c Sensor_Attributes.c sensor_config.c sensor_data_task.c sml_output.c watchdog.c
  group BSP/quickfeather/inc
    ../../../BSP/quickfeather/inc/: leds.h
  group BSP/quickfeather/src
    ../../../BSP/quickfeather/src/: qf_hardwaresetup.c
  group FreeRTOS
    ../../../FreeRTOS/: croutine.c event_groups.c freertos_static_memory.c list.c queue.c readme.txt stream_buffer.c tasks.c timers.c
  group FreeRTOS/include
    ../../../FreeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group FreeRTOS/include/portable/IAR/ARM_CM4F_quicklogic_s3XX
    ../../../FreeRTOS/portable/IAR/ARM_CM4F_quicklogic_s3XX/: port.c portasm.s portmacro.h
  group FreeRTOS/include/portable/MemMang
    ../../../FreeRTOS/portable/MemMang/: heap_4.c
  group freertos_gateware/inc
    ../../../freertos_gateware/inc/: eoss3_hal_fpga_ad7476_reg.h eoss3_hal_fpga_adc_api.h eoss3_hal_fpga_clk_sync.h eoss3_hal_fpga_gpio.h eoss3_hal_fpga_ltc1859_reg.h eoss3_hal_fpga_sdma_api.h eoss3_hal_fpga_sdma_reg.h eoss3_hal_fpga_uart.h eoss3_hal_fpga_usbserial.h
  group freertos_gateware/src
    ../../../freertos_gateware/src/: eoss3_hal_fpga_ad7476.c eoss3_hal_fpga_clk_sync.c eoss3_hal_fpga_gpio.c eoss3_hal_fpga_ltc1859.c eoss3_hal_fpga_sdma.c eoss3_hal_fpga_uart.c eoss3_hal_fpga_usbserial.c
  group HAL/inc
    ../../../HAL/inc/: eoss3_api.h eoss3_dev.h eoss3_hal_adc.h eoss3_hal_audio.h eoss3_hal_audio_config.h eoss3_hal_audio_reg.h eoss3_hal_def.h eoss3_hal_ffe.h eoss3_hal_gpio.h eoss3_hal_i2c.h eoss3_hal_i2s.h eoss3_hal_i2s_drv.h eoss3_hal_leds.h eoss3_hal_pad_config.h eoss3_hal_pads.h eoss3_hal_pkfb.h eoss3_hal_pmu_timer.h eoss3_hal_rtc.h eoss3_hal_sdma.h eoss3_hal_spi-p4org.h eoss3_hal_spi.h eoss3_hal_timer.h eoss3_hal_uart.h eoss3_hal_wb.h eoss3_hal_wdt.h s3x_clock_hal.h test_types.h
  group HAL/src
    ../../../HAL/src/: eoss3_hal_adc.c eoss3_hal_audio.c eoss3_hal_ffe.c eoss3_hal_gpio.c eoss3_hal_i2c.c eoss3_hal_i2s.c eoss3_hal_i2s_master_assp.c eoss3_hal_i2s_slave_assp.c eoss3_hal_pad_config.c eoss3_hal_pkfb.c eoss3_hal_rtc.c eoss3_hal_sdma.c eoss3_hal_spi.c eoss3_hal_timer.c eoss3_hal_uart.c eoss3_hal_wb.c eoss3_hal_wdt.c s3x_clock_hal.c
  group HAL/startup
    ../../../HAL/startup/: startup_EOSS3B_IAR.c vectors_CM4F_iar.c
  group Libraries/cli/inc
    ../../../Libraries/cli/inc/: cli.h
  group Libraries/cli/inc/cli
    ../../../Libraries/cli/inc/cli/: cli_args.h cli_filesystem.h cli_getkey.h cli_hw.h cli_misc.h cli_print.h cli_structs.h cli_time.h
  group Libraries/cli/src
    ../../../Libraries/cli/src/: cli_args.c cli_filesystem.c cli_fsminterface.c cli_hexdump.c cli_io.c cli_loop.c cli_misc.c cli_platform.c cli_stdcmds.c
  group Libraries/CMSIS/DSP
    ../../../Libraries/CMSIS_5/CMSIS/DSP/Lib/IAR/: arm_cortexM_math.a
  group Libraries/CMSIS/DSP/src
    ../../../Libraries/CMSIS/src/: arm_bitreversal2.S arm_cfft_f32.c arm_cfft_radix8_f32.c arm_common_tables.c arm_const_structs.c arm_dot_prod_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c
  group Libraries/CMSIS/math
    ../../../Libraries/CMSIS/src/: arm_add_q15.c arm_mult_q15.c arm_negate_q15.c arm_offset_q15.c arm_shift_q15.c arm_sub_q15.c
  group Libraries/CMSIS/NN
    ../../../Libraries/CMSIS/src/: arm_fully_connected_mat_q7_vec_q15_opt.c arm_nn_activations_q15.c arm_nntables.c arm_q15_to_float.c arm_relu_q15.c
  group Libraries/DatablockManager/inc
    ../../../Libraries/DatablockManager/inc/: datablk_mgr.h
  group Libraries/DatablockManager/src
    ../../../Libraries/DatablockManager/src/: datablk_mgr.c
  group Libraries/FPGA/inc
    ../../../Libraries/FPGA/inc/: fpga_loader.h
  group Libraries/FPGA/src
    ../../../Libraries/FPGA/src/: fpga_loader.c
  group Libraries/FreeRTOS_FAT
    ../../../Libraries/FreeRTOS_FAT/: ff_crc.c ff_dir.c ff_error.c ff_fat.c ff_file.c ff_format.c ff_ioman.c ff_locking.c ff_memory.c ff_stdio.c ff_string.c ff_sys.c ff_time.c History.txt
  group Libraries/FreeRTOS_FAT/include
    ../../../Libraries/FreeRTOS_FAT/include/: ff_crc.h ff_devices.h ff_dir.h ff_error.h ff_fat.h ff_fatdef.h ff_file.h ff_format.h ff_headers.h ff_ioman.h ff_locking.h ff_memory.h ff_old_config_defines.h ff_stdio.h ff_string.h ff_sys.h ff_time.h FreeRTOS_errno_FAT.h FreeRTOSFATConfig.h FreeRTOSFATConfigDefaults.h
  group Libraries/FreeRTOS_FAT/portable/common
    ../../../Libraries/FreeRTOS_FAT/portable/common/: ff_ramdisk.c ff_ramdisk.h ff_sddisk.h
  group Libraries/FreeRTOS_FAT/portable/QL
    ../../../Libraries/FreeRTOS_FAT/portable/QL/: ff_test_apis.c media_drv_spi.c media_drv_spi.h
  group Libraries/MQTTSN/inc
    ../../../Libraries/MQTTSN/inc/: MQTTSNConnect.h MQTTSNPacket.h MQTTSNPublish.h MQTTSNSearch.h MQTTSNSubscribe.h MQTTSNUnsubscribe.h StackTrace.h
  group Libraries/MQTTSN/src
    ../../../Libraries/MQTTSN/src/: MQTTSNConnectClient.c MQTTSNConnectServer.c MQTTSNDeserializePublish.c MQTTSNPacket.c MQTTSNSearchClient.c MQTTSNSerializePublish.c MQTTSNSubscribeClient.c MQTTSNUnsubscribeClient.c
  group Libraries/MQTTSN_SML/inc
    ../../../Libraries/MQTTSN_SML/inc/: Mqttsn_App.h Mqttsn_CliCmds.h Mqttsn_MessageHandler.h Mqttsn_Topics.h
  group Libraries/MQTTSN_SML/src
    ../../../Libraries/MQTTSN_SML/src/: MajorTopicDispatch.c MinorTopicDispatch_Collect.c MinorTopicDispatch_Live.c MinorTopicDispatch_Recog.c MinorTopicDispatch_Sensor.c MinorTopicDispatch_Storage.c MinorTopicDispatch_System.c Mqttsn_App.c Mqttsn_CliCmds.c Mqttsn_MsgHandler.c Mqttsn_Topics.c
  group Libraries/Power/inc
    ../../../Libraries/Power/inc/: s3x_clock.h s3x_cpuload.h s3x_dfs.h s3x_err_base.h s3x_lpm.h s3x_pi.h
  group Libraries/Power/src
    ../../../Libraries/Power/src/: s3x_clock.c s3x_cpuload.c s3x_dfs.c s3x_lpm.c s3x_pi.c s3x_qos.c
  group Libraries/QLFS/inc
    ../../../Libraries/QLFS/inc/: media_drv_defines.h media_drv_spi_sd.h mmc_s3.h ql_fs.h
  group Libraries/QLFS/src
    ../../../Libraries/QLFS/src/: freeRTOSFs_test.c media_drv_spi_sd.c mmc_s3.c ql_fs.c
  group Libraries/QLRC/inc
    ../../../Libraries/QLSRC/inc/: QL_InterpBy3.h TypeDefs.h
  group Libraries/QLSPI/inc
    ../../../Libraries/QLSPI/inc/: qlspi_fw_loader.h qlspi_s3.h tlc_reg.h
  group Libraries/QLSPI/src
    ../../../Libraries/QLSPI/src/: qlspi_fw_loader.c qlspi_s3.c
  group Libraries/riff_files/inc
    ../../../Libraries/riff_file/inc/: ql_riff.h
  group Libraries/riff_files/inc/riff_files
    ../../../Libraries/riff_file/inc/riff_file/: riff_block_pool.h riff_file.h riff_misc.h riff_writer.h
  group Libraries/riff_files/src
    ../../../Libraries/riff_file/src/: riff_block_pool.c riff_file.c riff_internal.h riff_misc.c riff_writer.c
  group Libraries/SensorFramework/drivers/FFE
    ../../../Libraries/SensorFramework/drivers/FFE/: Accel2_FFE_Drv.c Accel_ffe_drv.c DT_FFE_Drv.c Gyro_FFE_Drv.c Mag_FFE_Drv.c Sensiml_ffe_drv.c
  group Libraries/SensorFramework/drivers/inc
    ../../../Libraries/SensorFramework/drivers/inc/: QL_SDF_Accel.h QL_SDF_Gyro.h QL_SDF_Mag.h
  group Libraries/SensorFramework/drivers/M4/BMI160
    ../../../Libraries/SensorFramework/drivers/M4/BMI160/: Accel_BMI160.c
  group Libraries/SensorFramework/drivers/M4/LSM6DSL
    ../../../Libraries/SensorFramework/drivers/M4/LSM6DSL/: Accel_LSM6DSL.c Gyro_LSM6DSL.c LSM6DSL.h LSM6DSL_Accel.h LSM6DSL_Gyro.h
  group Libraries/SensorFramework/drivers/M4/mc3635
    ../../../Libraries/SensorFramework/drivers/M4/mc3635/: mc3635.c mc3635.h
  group Libraries/SensorFramework/inc
    ../../../Libraries/SensorFramework/inc/: ffe_ipc_lib.h QL_FFE_SensorConfig.h QL_SAL.h QL_SDF.h QL_SensorCommon.h ql_SensorHub_MemoryMap.h QL_SensorIoctl.h QL_Trace.h qlsh_commands.h
  group Libraries/SensorFramework/lib
    ../../../Libraries/SensorFramework/lib/: ffe_export_section.c ffe_ipc_lib.c
  group Libraries/SensorFramework/src
    ../../../Libraries/SensorFramework/src/: QL_SensorFramework.c QL_Trace.c
  group Libraries/SysFlash/inc
    ../../../Libraries/SysFlash/inc/: spi_flash.h
  group Libraries/SysFlash/src
    ../../../Libraries/SysFlash/src/: spi_flash.c
  group Libraries/Utils/inc
    ../../../Libraries/Utils/inc/: common.h crc16.h crc32.h dbg_queue_monitor.h dbg_uart.h micro_tick64.h ql_time.h
  group Libraries/Utils/src
    ../../../Libraries/Utils/src/: crc16.c crc32.c dbg_queue_monitor.c dbg_uart.c dbgtrace.c micro_tick64.c ql_time.c
  group s3-gateware
    ../../../s3-gateware/: gateware.h
  group s3-gateware/ad7476
    ../../../s3-gateware/adc_ad7476_if/src/: fpga.c
  group s3-gateware/usb2serial
    ../../../s3-gateware/usb2serial/src/: usb2serial.c
  group Tasks/ADC/inc
    ../../../Tasks/ADC/inc/: ql_adcTask.h
  group Tasks/ADC/src
    ../../../Tasks/ADC/src/: ql_adcTask.c
  group Tasks/BLE/inc
    ../../../Tasks/BLE/inc/: ql_bleTask.h
  group Tasks/BLE/src
    ../../../Tasks/BLE/src/: ql_bleTask.c
  group Tasks/datablk_processor/inc
    ../../../Tasks/DatablockProcessor/inc/: datablk_processor.h process_ids.h
  group Tasks/datablk_processor/src
    ../../../Tasks/DatablockProcessor/src/: datablk_processor.c
  group Tasks/SDCard/inc
    ../../../Tasks/SDCard/inc/: ql_sdcardTask.h
