<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\qf_mqttsn_ai_app.ewp</path>
    </project>
    <batchBuild />
</workspace>
