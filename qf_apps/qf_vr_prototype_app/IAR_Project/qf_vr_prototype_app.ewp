# IAR project qf_vr_prototype_app.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __FPU_PRESENT; __FPU_USED; __EOSS3_CHIP; __RTOS; configUSE_STATS_FORMATTING_FUNCTIONS; configUSE_TRACE_FACILITY; ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING
  ICCARM.IExtraOptions: --aeabi; --guard_calls; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\HAL\inc; ..\..\..\freertos_gateware\inc; ..\..\..\s3-gateware\; ..\..\..\s3-gateware\usb2serial\src; ..\..\..\FreeRTOS\include; ..\..\..\FreeRTOS\portable\IAR\ARM_CM4F_quicklogic_s3XX; ..\..\..\Licensed3rdParty\amazon\inc; ..\..\..\Libraries\Audio\inc; ..\..\..\Libraries\CMSIS\inc; ..\..\..\Libraries\FPGA\inc; ..\..\..\Libraries\Power\inc; ..\..\..\Libraries\Utils\inc; ..\..\..\Libraries\SysFlash\inc; ..\..\..\Libraries\CMSIS\DSP\Include; ..\..\..\Libraries\DatablockManager\inc; ..\..\..\Libraries\cli\inc; ..\..\..\Libraries\D2HProtocol\inc; ..\..\..\Libraries\CMSIS_5\CMSIS\Core\Include; ..\..\..\Libraries\CMSIS_5\CMSIS\DSP\Include; ..\..\..\Libraries\CMSIS_5\CMSIS\NN\Include; ..\..\..\BSP\quickfeather\inc; ..\fsm; ..\..\..\Tasks\Audio\inc; ..\..\..\Tasks\Control\inc; ..\..\..\Tasks\DatablockProcessor\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\inc; ..\..\..\FreeRTOS\include
  OBJCOPY.OOCOutputFile: qf_vr_prototype_app.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $PROJ_FNAME$.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: qf_vr_prototype_app.icf
  group BSP/quickfeather/inc
    ../../../BSP/quickfeather/inc/: flash_defines.h leds.h qf_hardwaresetup.h
  group BSP/quickfeather/src
    ../../../BSP/quickfeather/src/: leds.c qf_hardwaresetup.c
  group FreeRTOS
    ../../../FreeRTOS/: croutine.c event_groups.c freertos_static_memory.c list.c queue.c readme.txt stream_buffer.c tasks.c timers.c
  group FreeRTOS/include
    ../../../FreeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group FreeRTOS/include/portable/IAR/ARM_CM4F_quicklogic_s3XX
    ../../../FreeRTOS/portable/IAR/ARM_CM4F_quicklogic_s3XX/: port.c portasm.s portmacro.h
  group FreeRTOS/include/portable/MemMang
    ../../../FreeRTOS/portable/MemMang/: heap_4.c
  group freertos_gateware/inc
    ../../../freertos_gateware/inc/: eoss3_hal_fpga_uart.h eoss3_hal_fpga_usbserial.h
  group freertos_gateware/src
    ../../../freertos_gateware/src/: eoss3_hal_fpga_uart.c eoss3_hal_fpga_usbserial.c README.md
  group HAL/inc
    ../../../HAL/inc/: eoss3_api.h eoss3_dev.h eoss3_hal_adc.h eoss3_hal_audio.h eoss3_hal_audio_config.h eoss3_hal_audio_reg.h eoss3_hal_def.h eoss3_hal_ffe.h eoss3_hal_gpio.h eoss3_hal_i2c.h eoss3_hal_i2s.h eoss3_hal_i2s_drv.h eoss3_hal_leds.h eoss3_hal_pad_config.h eoss3_hal_pads.h eoss3_hal_pkfb.h eoss3_hal_pmu_timer.h eoss3_hal_rtc.h eoss3_hal_sdma.h eoss3_hal_spi-p4org.h eoss3_hal_spi.h eoss3_hal_timer.h eoss3_hal_uart.h eoss3_hal_wb.h eoss3_hal_wdt.h s3x_clock_hal.h test_types.h
  group HAL/src
    ../../../HAL/src/: eoss3_hal_adc.c eoss3_hal_audio.c eoss3_hal_ffe.c eoss3_hal_fpga_adc.c eoss3_hal_gpio.c eoss3_hal_i2c.c eoss3_hal_i2s.c eoss3_hal_i2s_master_assp.c eoss3_hal_i2s_slave_assp.c eoss3_hal_pad_config.c eoss3_hal_pkfb.c eoss3_hal_rtc.c eoss3_hal_sdma.c eoss3_hal_spi.c eoss3_hal_timer.c eoss3_hal_uart.c eoss3_hal_wb.c eoss3_hal_wdt.c s3x_clock_hal.c
  group HAL/startup
    ../../../HAL/startup/: startup_EOSS3B_IAR.c vectors_CM4F_iar.c
  group Libraries/Audio/inc
    ../../../Libraries/Audio/inc/: audio_circularbuffer.h audio_encode_opus.h audio_raw_pcm_buffer.h audio_stereo2mono.h dma_buffer.h ql_audio.h ql_i2stx_pe.h ql_vr_common.h
  group Libraries/Audio/src
    ../../../Libraries/Audio/src/: audio_circularbuffer.c audio_raw_pcm_buffer.c ql_audio.c tempFunc.c
  group Libraries/cli/inc
    ../../../Libraries/cli/inc/: cli.h
  group Libraries/cli/inc/cli
    ../../../Libraries/cli/inc/cli/: cli_args.h cli_filesystem.h cli_getkey.h cli_hw.h cli_misc.h cli_print.h cli_structs.h cli_time.h
  group Libraries/cli/src
    ../../../Libraries/cli/src/: cli_args.c cli_filesystem.c cli_fsminterface.c cli_hexdump.c cli_io.c cli_loop.c cli_misc.c cli_platform.c cli_stdcmds.c
  group Libraries/CMSIS_5/CMSIS/Core/Include
    ../../../Libraries/CMSIS_5/CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h
  group Libraries/CMSIS_5/CMSIS/DSP/Include
    ../../../Libraries/CMSIS_5/CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h
  group Libraries/CMSIS_5/CMSIS/DSP/lib/IAR
    ../../../Libraries/CMSIS_5/CMSIS/DSP/Lib/IAR/: iar_cortexM4lf_math.a
  group Libraries/CMSIS_5/CMSIS/NN/Include
    ../../../Libraries/CMSIS_5/CMSIS/NN/Include/: arm_nn_tables.h arm_nnfunctions.h arm_nnsupportfunctions.h
  group Libraries/CMSIS_5/CMSIS/NN/Source/ActivationFunctions
    ../../../Libraries/CMSIS_5/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q15.c arm_relu_q15.c
  group Libraries/CMSIS_5/CMSIS/NN/Source/FullyConnectedFunctions
    ../../../Libraries/CMSIS_5/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15_opt.c
  group Libraries/CMSIS_5/CMSIS/NN/Source/NNSupportFunctions
    ../../../Libraries/CMSIS_5/CMSIS/NN/Source/NNSupportFunctions/: arm_nntables.c
  group Libraries/D2HProtocol/inc
    ../../../Libraries/D2HProtocol/inc/: d2h_protocol.h
  group Libraries/D2HProtocol/src
    ../../../Libraries/D2HProtocol/src/: d2h_protocol.c
  group Libraries/DatablockManager/inc
    ../../../Libraries/DatablockManager/inc/: datablk_mgr.h
  group Libraries/DatablockManager/src
    ../../../Libraries/DatablockManager/src/: datablk_mgr.c
  group Libraries/debug/src
    ../../../Libraries/debug/src/: print_s3_registers.c
  group Libraries/FPGA/inc
    ../../../Libraries/FPGA/inc/: fpga_loader.h
  group Libraries/FPGA/src
    ../../../Libraries/FPGA/src/: fpga_loader.c
  group Libraries/FreeRTOS_FAT
    ../../../Libraries/FreeRTOS_FAT/: ff_crc.c ff_dir.c ff_error.c ff_fat.c ff_file.c ff_format.c ff_ioman.c ff_locking.c ff_memory.c ff_stdio.c ff_string.c ff_sys.c ff_time.c History.txt
  group Libraries/FreeRTOS_FAT/include
    ../../../Libraries/FreeRTOS_FAT/include/: ff_crc.h ff_devices.h ff_dir.h ff_error.h ff_fat.h ff_fatdef.h ff_file.h ff_format.h ff_headers.h ff_ioman.h ff_locking.h ff_memory.h ff_old_config_defines.h ff_stdio.h ff_string.h ff_sys.h ff_time.h FreeRTOS_errno_FAT.h FreeRTOSFATConfig.h FreeRTOSFATConfigDefaults.h
  group Libraries/FreeRTOS_FAT/portable/common
    ../../../Libraries/FreeRTOS_FAT/portable/common/: ff_ramdisk.c ff_ramdisk.h ff_sddisk.h
  group Libraries/FreeRTOS_FAT/portable/QL
    ../../../Libraries/FreeRTOS_FAT/portable/QL/: ff_test_apis.c media_drv_spi.c media_drv_spi.h
  group Libraries/Opus/inc
    ../../../Libraries/Opus/inc/: ql_opus.h
  group Libraries/Opus/lib
    ../../../Libraries/Opus/lib/: libopus.a readme.txt
  group Libraries/Power/inc
    ../../../Libraries/Power/inc/: s3x_clock.h s3x_cpuload.h s3x_dfs.h s3x_err_base.h s3x_fsm_interface.h s3x_lpm.h s3x_pi.h
  group Libraries/Power/src
    ../../../Libraries/Power/src/: s3x_clock.c s3x_cpuload.c s3x_dfs.c s3x_fsm_interface.c s3x_lpm.c s3x_pi.c s3x_qos.c
  group Libraries/QLFS/inc
    ../../../Libraries/QLFS/inc/: media_drv_defines.h media_drv_spi_sd.h mmc_s3.h ql_fs.h
  group Libraries/QLFS/src
    ../../../Libraries/QLFS/src/: freeRTOSFs_test.c media_drv_spi_sd.c mmc_s3.c ql_fs.c
  group Libraries/QLRC/inc
    ../../../Libraries/QLSRC/inc/: QL_InterpBy3.h TypeDefs.h
  group Libraries/QLSPI/inc
    ../../../Libraries/QLSPI/inc/: qlspi_fw_loader.h qlspi_s3.h tlc_reg.h
  group Libraries/QLSPI/src
    ../../../Libraries/QLSPI/src/: qlspi_fw_loader.c qlspi_s3.c
  group Libraries/rdsp/inc
    ../../../Libraries/rdsp/inc/: ql_vr_rdsp.h vs_process.h
  group Libraries/rdsp/inc/public
    ../../../Libraries/rdsp/inc/public/: rdsp_model.h rdsp_model_defines.h rdsp_voicespot.h rdsp_voicespot_defines.h rdsp_voicespot_utils.h
  group Libraries/rdsp/lib
    ../../../Libraries/rdsp/lib/: libRDSP_VS_MODEL_CM4.a libRDSP_VS_VOICESPOT_CM4_IAR.a
  group Libraries/rdsp/models/Alexa/en-US
    ../../../Libraries/rdsp/models/Alexa/EN-US/: Alexa_model-standard_en-US_4_SmallVocabularyCompatible_oct_03.h
  group Libraries/rdsp/src
    ../../../Libraries/rdsp/src/: ql_vr_rdsp.c
  group Libraries/riff_files/inc
    ../../../Libraries/riff_file/inc/: ql_riff.h
  group Libraries/riff_files/inc/riff_files
    ../../../Libraries/riff_file/inc/riff_file/: riff_block_pool.h riff_file.h riff_misc.h riff_writer.h
  group Libraries/riff_files/src
    ../../../Libraries/riff_file/src/: riff_block_pool.c riff_file.c riff_internal.h riff_misc.c riff_writer.c
  group Libraries/SensorFramework/drivers/FFE
    ../../../Libraries/SensorFramework/drivers/FFE/: Accel2_FFE_Drv.c Accel_ffe_drv.c DT_FFE_Drv.c Gyro_FFE_Drv.c Mag_FFE_Drv.c Sensiml_ffe_drv.c
  group Libraries/SensorFramework/drivers/inc
    ../../../Libraries/SensorFramework/drivers/inc/: QL_SDF_Accel.h QL_SDF_Gyro.h QL_SDF_Mag.h
  group Libraries/SensorFramework/drivers/M4/BMI160
    ../../../Libraries/SensorFramework/drivers/M4/BMI160/: Accel_BMI160.c
  group Libraries/SensorFramework/drivers/M4/LSM6DSL
    ../../../Libraries/SensorFramework/drivers/M4/LSM6DSL/: Accel_LSM6DSL.c Gyro_LSM6DSL.c LSM6DSL.h LSM6DSL_Accel.h LSM6DSL_Gyro.h
  group Libraries/SensorFramework/inc
    ../../../Libraries/SensorFramework/inc/: ffe_ipc_lib.h QL_FFE_SensorConfig.h QL_SAL.h QL_SDF.h QL_SensorCommon.h ql_SensorHub_MemoryMap.h QL_SensorIoctl.h
  group Libraries/SensorFramework/lib
    ../../../Libraries/SensorFramework/lib/: ffe_export_section.c ffe_ipc_lib.c
  group Libraries/SensorFramework/src
    ../../../Libraries/SensorFramework/src/: QL_SensorFramework.c QL_Trace.c
  group Libraries/SysFlash/inc
    ../../../Libraries/SysFlash/inc/: spi_flash.h
  group Libraries/SysFlash/src
    ../../../Libraries/SysFlash/src/: spi_flash.c
  group Libraries/Utils/inc
    ../../../Libraries/Utils/inc/: common.h crc32.h dbg_queue_monitor.h dbg_uart.h dbgtrace.h ql_stackwatermark.h ql_time.h QL_Trace.h ql_util.h qlsh_commands.h
  group Libraries/Utils/src
    ../../../Libraries/Utils/src/: crc32.c dbg_bufferedprinttask.c dbg_queue_monitor.c dbg_uart.c dbgtrace.c ql_stackwatermark.c ql_test_signals.c ql_time.c
  group Licensed3rdParty/amazon
    ../../../Libraries/Amazon/: Readme.txt
  group Licensed3rdParty/amazon/inc
    ../../../Licensed3rdParty/amazon/inc/: pryon_lite.h pryon_lite_error.h pryon_lite_metadata.h pryon_lite_PRL1000.h pryon_lite_vad.h pryon_lite_ww.h
  group Licensed3rdParty/amazon/lib
    ../../../Licensed3rdParty/amazon/lib/: libpryon_lite-PRL1000.a libpryon_lite-U.a
  group Licensed3rdParty/amazon/src
    ../../../Licensed3rdParty/amazon/src/: ql_vr_amazon.c ql_vr_engine_api.c W_50k.en-US.alexa.c
  group qf_apps/qf_vr_prototype_app/fsm
    ../fsm/: fsm.c fsm.h fsm_cli_table.c
  group qf_apps/qf_vr_prototype_app/inc
    ../inc/: Bootconfig.h FreeRTOSConfig.h FreeRTOSFATConfig.h Fw_global_config.h Fw_task.h host_interface.h RtosTask.h s3_host_proto_defs.h s3x_pwrcfg.h sec_debug.h vr_engine_api.h ww_metadata.h
  group qf_apps/qf_vr_prototype_app/src
    ../src/: arm_rfft_fast_init_f32.c c_lib_retarget.c exceptions.c hif_command_table.c host_interface.c main.c main_dbg_cli_menu.c qf_hardwaresetup.c ql_vr_app.c ql_vr_pe_generic.c s3x_pwrcfg.c sec_debug.c vr_engine_api.c watchdog.c
  group s3-gateware
    ../../../s3-gateware/: gateware.h
  group s3-gateware/usb2serial/src
    ../../../s3-gateware/usb2serial/src/: usb2serial.c usb2serial_bit.h
  group Tasks/Audio/inc
    ../../../Tasks/Audio/inc/: dma_buffer.h ql_audioTask.h
  group Tasks/Audio/src
    ../../../Tasks/Audio/src/: ql_audioTask.c
  group Tasks/BLE/inc
    ../../../Tasks/BLE/inc/: ql_bleTask.h
  group Tasks/BLE/src
    ../../../Tasks/BLE/src/: ql_bleTask.c
  group Tasks/Control/inc
    ../../../Tasks/Control/inc/: ql_controlDefines.h ql_controlTask.h
  group Tasks/Control/src
    ../../../Tasks/Control/src/: ql_controlTask.c
  group Tasks/DatablockProcessor/inc
    ../../../Tasks/DatablockProcessor/inc/: datablk_processor.h process_ids.h
  group Tasks/DatablockProcessor/src
    ../../../Tasks/DatablockProcessor/src/: datablk_processor.c
  group Tasks/SDCard/inc
    ../../../Tasks/SDCard/inc/: ql_sdcardTask.h
