<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\qf_vr_prototype_app.ewp</path>
    </project>
    <batchBuild />
</workspace>
